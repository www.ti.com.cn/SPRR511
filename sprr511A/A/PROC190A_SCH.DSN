# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 16 to 17 of 57

## Sheets
16 14. SOC POWER SUPPLY PMIC - 1: size C; title: SOC POWER SUPPLY PMIC - 1
17 15. SOC POWER SUPPLY PMIC - 2: size C; title: SOC POWER SUPPLY PMIC - 2

## Parts
sheet 14. SOC POWER SUPPLY PMIC - 1
C226  22uF  [CAP0603_1]
C227  47uF  [CAP0805_1-5]
C228  47uF  [CAP0805_1-5]
C229  22uF  [CAP0603_1]
C242  2.2uF  [CAP0603_1]
C246  2.2uF  [CAP0603_1]
C249  2.2uF  [CAP0603_1]
C254  2.2uF  [CAP0603_1]
C256  2.2uF  [CAP0603_1]
C257  22uF  [CAP0603_1]
C258  22uF  [CAP0603_1]
C259  2.2uF  [CAP0603_1]
C260  0.1uF  [CAP0603_1]
C261  0.1uF  [CAP0603_1]
C532  0.1uF  [CAP0603_1]
C533  100uF  [CAP1210_2-75]
C534  100uF  [CAP1210_2-75]
C535  2.2uF  [CAP0603_1]
C536  2.2uF  [CAP0603_1]
C537  0.1uF  [CAP0603_1]
C538  0.1uF  [CAP0201_0-5]
C546  10uF  [CAP0805_1-5]
C547  10uF  [CAP0805_1-5]
C555  0.47uF  [CAP0402_0-75]
C561  4.7uF  [CAP0402_0-75]
C565  10uF  [CAP0805_1-5]
C572  10uF  [CAP0805_1-5]
C576  0.47uF  [CAP0402_0-75]
C592  47uF  [CAP0805_1-5]
C593  47uF  [CAP0805_1-5]
C3731  0.1uF  [CAP0201_0-5]
C3738  2.2uF  [CAP0603_1]
C3746  0.1uF  [CAP0201_0-5]
C3747  1uF  [CAP0201_0-5]
C3750  22pF  [CAP0201_0-5]
D2  PLVA650A  [DIO_SOT23_123]
D5  BAT54CWT1G  [DIO_SOT323-3_1-1]
J16  HDR_1X2  [HDR_1X2_61300211121_S_T_8-6]
L4  0.22uH  [IND1210_1-2]
L5  0.22uH  [IND1210_1-2]
L6  0.22uH  [IND1210_1-2]
L7  0.22uH  [IND1210_1-2]
Q4  BSS138LT1G  [SOT23-123_1-2]
R243  0E  [RES0402_0-5]
R265  0.001E_1%  [RES_CST0612_0612-4_0-9]
R281  0E  [RES0201_0-5]
R282  10K  [RES0201_0-5]
R288  10K  [RES0201_0-5]
R290  0E  [RES0201_0-5]
R291  10K  [RES0201_0-5]
R293  0E  [RES0201_0-5]
R294  0E  [RES0201_0-5]
R296  0E  [RES0201_0-5]
R297  0E  [RES0201_0-5]
R298  2K_1%  [RES0402_0-5]
R299  0E  [RES0201_0-5]
R300  0E  [RES0201_0-5]
R303  1.3K_1%  [RES0402_0-5]
R307  0E  [RES0201_0-5]
R308  1K_1%  [RES0402_0-5]
R316  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
R317  0E  [RES0201_0-5]
R318  10K  [RES0402_0-5]
R327  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
R334  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
R581  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
R5736  10K  [RES0402_0-5]
R5737  100K  [RES0402_0-5]
R5747  0E  [RES0603_0-75]
R5748  0E  [RES0603_0-75]
R5766  4.7K  [RES0201_0-5]
R5773  1.1K_1%  [RES0603_0-5]
R5774  10K_1%  [RES0603_0-75]
R5828  0E  [RES0402_0-5]
R5829  0E  [RES0402_0-5]
TP53  TP20_SMD  [TP20_SMD]
TP56  TP20_SMD  [TP20_SMD]
TP60  TP20_SMD  [TP20_SMD]
TP67  TP20_SMD  [TP20_SMD]
TP70  TP20_SMD  [TP20_SMD]
TP72  TP30_SMD  [TP30_SMD]
TP73  TP30_SMD  [TP30_SMD]
TP74  TP20_SMD  [TP20_SMD]
TP79  TP20_SMD  [TP20_SMD]
TP80  TP40_SMD  [TP40_SMD]
TP81  TP40_SMD  [TP40_SMD]
TP83  TP20_SMD  [TP20_SMD]
TP86  TP20_SMD  [TP20_SMD]
TP106  TP40_SMD  [TP40_SMD]
U54  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]
U56  TPS6522435RAHRQ1  [VQFN-HR36-35_TPS65224_240X200_1]
U2356  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]
U3076  TPS22919DCKR  [SC70-6_1-1]
sheet 15. SOC POWER SUPPLY PMIC - 2
C613  0.1uF  [CAP0201_0-5]
D13  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
LD2  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
LD4  150040VS73220  [LED_150040GS73220_40X20_SMD_0-4]
LD6  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
Q2  ABC817-40-HF  [SOT23-123_1-2]
Q3  BSS138LT1G  [SOT23-123_1-2]
R260  220E  [RES0402_0-5]
R272  1K  [RES0402_0-5]
R286  0E  [RES0201_0-5]
R292  220E  [RES0402_0-5]
R324  220E  [RES0402_0-5]
R371  10K  [RES0201_0-5]
SW7  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
TP76  TP20_SMD  [TP20_SMD]

## Library data of the parts
C226 C229 C257 C258 = CAP: CAP CERAMIC 22uF 10V 20% X5R AUTO 0603; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85369090; Distributor_name: MOUSER; Distributor_part_number: 81-GRT188R61A226ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT188R61A226ME13D; Mistral Part No: 120021020033-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT188R61A226ME13.PDF
C227 C228 C592 C593 = CAP: CAP CERAMIC 47uF 10V 20% X5R 0805; Chkd/date: MANIRAJA/181018; Crtd /date: ALVY/181018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-9961-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM21BR61A476ME15L; Mistral Part No: 120014100011-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: RFID_MODULE-DESIGN; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 9.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM21BR61A476ME15L.PDF
C242 C246 C249 C254 C256 C259 C535 C536 C3738 = CAP: CAP CERAMIC 2.2uF 6.3V 10% X7R 0603; Chkd/date: PRADEEP/080324; Crtd /date: TAMILARASU/080324; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM188R70J225KE15; Mistral Part No: 120024030008-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: AM62D_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 6.3V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM188R70J225KE15.PDF
C260 C261 C532 C537 = CAP: CAP CERAMIC 0.1uF 16V 10% X7R 0603; Chkd/date: MANIRAJA/290319; Crtd /date: MANIRAJA/290319; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 399-1096-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.95MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: KEMET; Mfr_part_number: C0603C104K4RACTU; Mistral Part No: 120009030076-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: DDAQ; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\KEMET-C-X7R.PDF
C533 C534 = CAP: CAP CERAMIC 100uF 6.3V 20% X5R AUTO 1210; Chkd/date: VASANTHA/290116; Crtd /date: VASANTHA/290116; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12498-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT32ER60J107ME13L; Mistral Part No: 120016010017-R; Package: 1210; Part_type: CAPACITORS\CERAMIC; Project: USHUS-2; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: 16mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT32ER60J107ME13L.PDF
C538 C3731 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C546 C547 C565 C572 = CAP: CAP CERAMIC 10uF 25V 10% X7S 0805; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT21BC71E106KE13LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT21BC71E106KE13L; Mistral Part No: 120022060025-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT21BC71E106KE13L.PDF
C555 C576 = CAP: CAP CERAMIC 0.47uF 10V 10% X7R 0402; Chkd/date: MANIRAJA/310821; Crtd /date: ALVY/310821; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-14366-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R71A474KE01D; Mistral Part No: 120021060019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_AM335x SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R71A474KE01.PDF
C561 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R61A475ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61A475ME13D; Mistral Part No: 120021020032-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61A475ME13.PDF
C613 C3746 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C3747 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C3750 = CAP: CAP CERAMIC 22pF 25V 1% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E220FA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E220FA02D; Mistral Part No: 120021120014-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 1%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E220FA02.PDF
D2 = DIODE_ZENER_SOT23_13: DIODE ZENER 250MW 5V SOT23-3; Chkd/date: PRAVEEN/260722; Crtd /date: PRAVEEN/260722; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: 1727-5167-1-ND; Height: 1.10MM; Mfr_name: NEXPERIA; Mfr_part_number: PLVA650A,215; Mistral Part No: 130022070034-R; Package: SOT23-3; Part_type: DIODE\ZENER; Project: BASEBAND_HARDWARE BRD; RoHS: Pb-Free; Temperature: -65°C+150°C; Tolerance: NA; Voltage: 5V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\PLVA6xxA.PDF
D5 = DIODE_BAT54CW_SOT323-123: DIODE SCHOTTKY 30V 200mA SOT323-3; Chkd/date: PRADEEP/280923; Crtd /date: PRADEEP/280923; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: BAT54CWT1GOSCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: ONSEMI; Mistral Part No: 130023090028-R; Package: SOT323-3; Part_type: DIODE\SCHOTTKY; Project: AM62P SK; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: 30V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\BAT54CWT1G.PDF
J16 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: MANIRAJA/031018; Crtd /date: ALVY/031018; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5315-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.54MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 61300211121; Mistral Part No: 150018100003-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: ALPINE_EVM; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 120mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\6130XXX.PDF
L4-L7 = INDUCTOR: IND POWER 0.22uH 7A 20% AUTO 1210; Chkd/date: TAMILARASU/020323; Crtd /date: TAMILARASU/020323; Custom_Duty: 0.24; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 445-TFM322512ALMAR22MTAACT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TDK CORPORATION; Mfr_part_number: TFM322512ALMAR22MTAA; Mistral Part No: 130023030003-R; Package: 1210; Project: AM62P SK; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: 20%; Voltage: NA; Wattage: NA; Weight: 52mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\TFM322512ALMA-SER.PDF
Q3 Q4 = MOSFET_BSS138W: IC MOSFET N-CHANNEL 50V 200mA SOT23-3; Chkd/date: MANIRAJA/250219; Crtd /date: JEBRAN/060416; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: BSS138LT1GOSCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.11MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Mfr_name: ON SEMICONDUCTOR; Mistral Part No: 142016040001-R; Package: SOT23-3; Part_type: ICS\POWER\MOSFET; Project: LRDE_ABCM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\BSS138LT1G.PDF
R243 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R265 = RESISTOR-4TERM: RES CURRENT SENSE 0.001E 1W 1% 0612-4; Chkd/date: MANIRAJA/261018; Crtd /date: ALVY/261018; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: CST0612-FC-R001ECT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.85MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: BOURNS; Mfr_part_number: CST0612-FC-R001E; Mistral Part No: 110018100018-R; Package: 0612-4; Part_type: RESISTORS\FIXED; Project: TI_J7ES_EVM_SOM; RoHS: RoHS; Temperature: -55°C+170°C; Tolerance: 1%; Voltage: NA; Wattage: 1W; Weight: 13.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CST0612-SERIES.PDF
R281 R286 R290 R293 R294 R296 R297 R299 R300 R307 R317 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R282 R288 R291 R371 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R298 = RESISTOR: RES 2K 1/10W 1% 0402; Chkd/date: SHREESHAIL/210506; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P2.00KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF2001X; Mistral Part No: 110009030606-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R303 = RESISTOR: RES 1.3K 1/10W 1% 0402; Chkd/date: MANIRAJA/131218; Crtd /date: ALVY/131218; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.30KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1301X; Mistral Part No: 110018120014-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: NPOL_32SC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R308 = RESISTOR: RES 1K 1/10W 1% 0402; Chkd/date: VASANTHA/281216; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.00KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1001X; Mistral Part No: 110009030411-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R316 R327 R334 R581 = RESISTOR-4TERM: RES 0.01E 1W 1% 1206-4; Chkd/date: MANIRAJA/060318; Crtd /date: MANIRAJA/060318; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 408-1974-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: SUSUMU; Mfr_part_number: KRL3216T4A-M-R010-F-T1; Mistral Part No: 110018030003-R; Package: 1206-4; Part_type: RESISTORS\FIXED; Project: GRACO SMART MODULE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1W; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\KRL-SERIES.PDF
R318 R5736 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5737 = RESISTOR: RES 100K 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ104X; Mistral Part No: 110009030177-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5747 R5748 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5766 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5773 = RESISTOR: RES 1.1K 1/10W 1% 0603; Chkd/date: MAZHAR/101210; Crtd /date: BAVISH/101210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-1.10KHCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.50MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW06031K10FKEA; Mistral Part No: 110010120049-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: IEMS; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R5774 = RESISTOR: RES 10K 1/10W 1% 0603; Chkd/date: MANIRAJA/061218; Crtd /date: ALVY/061218; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-5136-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW060310K0FKEAC; Mistral Part No: 110014070036-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: RFSU_POC-CARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW_C-SER.PDF
R5828 R5829 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0402_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP53 TP56 TP60 TP67 TP70 TP74 TP76 TP79 TP83 TP86 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
TP72 TP73 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
TP80 TP81 TP106 = TESTPOINT: TESTPOINT CIR 40 SMD; Chkd/date: MAZHAR/190505; Crtd /date: MAZHAR/190505; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030933; Package: SMD; Project: RAINIER-3; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U54 = SN74LVC1G11DCKR_SC70-6: IC SINGLE 3-INPUT POSITIVE-AND GATE SON6; Chkd/date: MANIRAJA/270121; Crtd /date: ALVY/270121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30120-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021010013-R; Package: SON6; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G_NOV16.PDF
U56 = TPS65224_VQFN-HR36: IC POWER MANAGEMENT IC (PMIC) WITH 4 BUCKS AND 3 LDOS FOR SAFETYRELEVANT AUTOMOTIVE APPLICATIONS VQFN-HR36-35; Chkd/date: PRAVEEN/210223; Crtd /date: TAMILARASU/210223; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Height: 1.00MM; MECHANICAL 3D STEP FILE: NA; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142023060009-R; Package: VQFN-HR36-35; Part_type: ICS\POWER\MANAGEMENT; Project: AM62P_SK_BRD; RoHS: NA; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS65224-Q1.PDF
U2356 = TMUX1136_USON10: IC 5V LOW-LEAKAGE-CURRENT 2:1 2-CHANNEL PRECISION ANALOG SWITCH USON10; Chkd/date: MANIRAJA/291121; Crtd /date: ALVY/291121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-TMUX1136DQARCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_ANALOG-APPLICATION_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140121110003-R; Package: USON10; Part_type: ICS\ANALOG\SWITCH; Project: TI_AM263x_CC_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 4.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ANALOG\TMUX1136.PDF
U3076 = TPS22919_SC70-6: IC 5.5V 1.5A 90mE SELF PROTECTED LOAD SWITCH CONTROLLED RISE TIME SC70-6; Chkd/date: MANIRAJA/090519; Crtd /date: ALVY/090519; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: MOUSER; Distributor_part_number: 595-TPS22919DCKR; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142019050003-R; Package: SC70-6; Part_type: ICS\POWER\CONTROL; Project: AM654x SOM_TEST_JIG; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS22919.PDF
D13 = DIODE_SOD323: DIODE 1CH ESD PROTECTION X1SON2; Chkd/date: MANIRAJA/040420; Crtd /date: VASANTHA/181114; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30406-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130014110022-R; Package: X1SON2; Part_type: DIODE; Project: GALILEO_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD1E10B06-SER.PDF
LD2 LD6 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
LD4 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/261120; Crtd /date: ALVY/261120; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-13425-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONIK; Mistral Part No: 130020110071-R; Package: SMD; Part_type: OPTO\LED; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 29.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150040VS73220.PDF
Q2 = NPN_123_SOT23-3: TRANSISTOR 45V 500mA NPN GENERAL PURPOSE SOT23-3; Chkd/date: PRAVEEN/260822; Crtd /date: PRAVEEN/260822; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: MOUSER; Distributor_part_number: 750-ABC817-40-HF; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Mfr_name: COMCHIP; Mistral Part No: 142022080040-R; Package: TO-252-3; Part_type: TRANSISTOR\BJT; Project: MS_TI_TMDS64SKEVM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: 45V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\ABC817-40-HF.PDF
R260 R292 R324 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R272 = RESISTOR: RES 1K 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.0KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ102X; Mistral Part No: 110009030400-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
SW7 = 7914G-1-000E__7914G: SWITCH SPST-NO 4MM SQ SMD 7914G; Chkd/date: VASANTHA/271216; Crtd /date: BAVISH/051010; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 7914G-000ECT-ND; Height: 4.19MM; Library Ref: 7914G-1-000E _7914G; Mfr_name: BOURNS; Mistral Part No: 130015110004-R; Package: 7914G; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: AAAUC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\7914G-1-000E.PDF

## Nets
DGND: C226.2 C227.2 C228.2 C229.2 C242.2 C246.2 C249.2 C254.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C546.2 C547.2 C555.2 C561.2 C565.2 C572.2 C576.2 C592.2 C593.2 C613.1 C3731.2 C3738.2 C3746.1 C3747.2 C3750.1 D2.1(A) D13.1 J16.2 LD6.1(CATHODE) Q2.2(EMITTER) Q3.2(S) R303.2 R5766.2 R5773.2 R5829.1 SW7.1 SW7.4 TP106.1(TP) U54.2(GND) U56.5(AGND) U56.14(PGND_B34) U56.32(PGND_B12) U2356.3(GND) U3076.2(GND) ; also on sheet 1 2 12 13 14 15 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
DVDD3V3_N: R327.4 ; also on sheet 49
DVDD3V3_P: R327.1 ; also on sheet 49
VBUS_TYPEC1: D5.1(A1) ; also on sheet 12 13
VBUS_TYPEC2: D5.2(A2) ; also on sheet 12 37
VCC1V8_SYS: C242.1 C256.1 C257.1 C261.1 C555.1 C593.1 L6.2 R288.1 R291.1 R334.2 U56.18(VIO) U56.26(PVIN_LDO3) ; also on sheet 21 22 23 24 26 27 28 29 31 34 38 39 40 42 43 44 46 47 48 52 54 56
VCC1V8_SYS_N: R334.4 ; also on sheet 49
VCC1V8_SYS_P: R334.1 ; also on sheet 49
VCC1V8_SYS_SW: L6.1 U56.13(SW_B3)
VCC_0V85: C3738.1 R5747.1 U56.25(VOUT_LDO3)
VCC_3V3_SYS: C258.1 C259.1 C260.1 C592.1 L7.2 R260.2 R292.2 R324.2 R327.2 ; also on sheet 1 2 12 23 28 29 31 34 35 36 38 40 44 47 48 49 50 55 56
VCC_3V3_SYS_REG_SW: L7.1 U56.15(SW_B4)
VCC_5V0: C546.1 C547.1 C561.1 C565.1 C572.1 C576.1 C3747.1 R5774.1 U56.3(VCCA) U56.12(PVIN_B3) U56.16(PVIN_B4) U56.20(PVIN_LDO12) U56.30(PVIN_B2) U56.34(PVIN_B1) U3076.1(IN) ; also on sheet 1 12 14 15 18 37 42 43 45
VCC_5V0_PG: U54.3(B) ; also on sheet 14 23
VCC_CORE: C226.1 C227.1 C228.1 C229.1 C532.1 C533.1 C534.1 C535.1 C536.1 C537.1 L4.2 L5.2 R265.4 R5748.1
VCC_CORE_N: R265.2 ; also on sheet 49
VCC_CORE_P: R265.3 ; also on sheet 49
VDD_0V85_N: R581.1 ; also on sheet 49
VDD_0V85_P: R581.4 ; also on sheet 49
VDD_1V8_N: R316.4 ; also on sheet 49
VDD_1V8_P: R316.1 ; also on sheet 49
VDD_CORE: R265.1 R5828.1 TP53.1(TP) ; also on sheet 18 19 20
VDD_CORE_REG_SW1: L4.1 U56.33(SW_B1)
VDD_CORE_REG_SW2: L5.1 U56.31(SW_B2)
VDDA1V8: C254.1 R316.2 U56.19(VOUT_LDO1) ; also on sheet 22
VDDA_1V8: R316.3 TP79.1(TP) ; also on sheet 19 20 33
VDDR_CORE: R272.1 R581.2 TP60.1(TP) ; also on sheet 18 19
VDDR_CORE_0V85: R581.3 R5747.2 R5748.2
VDDSHV_CANUART: C538.1 C3731.1 R282.1 R318.2 R371.1 R5736.2 R5737.2 TP80.1(TP) U54.5(VCC) U2356.8(VDD) ; also on sheet 14 15 23 24 45 46 52
VDDSHV_SDIO: C246.1 R243.1 U56.21(VOUT_LDO2) ; also on sheet 20 29
VINT_LDO: C249.1 TP74.1(TP) U56.7(VOUT_LDOVINT)
CORE_CONFIG: R371.2 SW7.3 TP76.1(TP) U56.8(GPIO3)
I2C0_SCL_1V8: R296.1 ; also on sheet 22 31 38 39 40 41 47 48
I2C0_SDA_1V8: R294.1 ; also on sheet 22 31 38 39 40 41 47 48
MCU_INTn: R299.1 ; also on sheet 31
MCU_SAFETY_ERRORz_1V8: R281.1 ; also on sheet 23
MMC0_SDIO_VSEL: U56.11(GPIO5) ; also on sheet 21
PMIC_EN: R317.2 U56.17(EN/PB/VSENSE)
PMIC_ENABLE: U54.6(C) U2356.10(D1)
PMIC_I2C_SCL_1V8: R296.2 TP72.1(TP) U56.1(SCL_I2C1/SCK_SPI)
PMIC_I2C_SDA_1V8: R294.2 TP73.1(TP) U56.2(SDA_I2C1/SDI_SPI)
PMIC_INT_B: R288.2 R299.2 R300.2 TP70.1(TP) U56.27(~{INT}/EN_DRV)
PMIC_INTn: R300.1 ; also on sheet 23
PMIC_LPM_EN0: R5737.1 U2356.2(S1A) U2356.7(S2B) ; also on sheet 21
PMIC_LPM_SEL: J16.1 R318.1 U2356.1(SEL1) U2356.5(SEL2)
PMIC_nSLEEP: U56.10(GPIO4) U2356.6(D2)
PMIC_POWERGOOD: R290.1 ; also on sheet 23
PMIC_RSTOUT: R286.1 R290.2 R291.2 TP67.1(TP) U56.28(~{RSTOUT})
SOC_DVDD1V8: R334.3 TP86.1(TP) U56.24(FB_B3) ; also on sheet 18 19
SOC_DVDD3V3: R327.3 TP83.1(TP) U56.22(FB_B4) ; also on sheet 18 19 20
SoC_VDDSHV5_SDIO: R243.2 ; also on sheet 18 20
TEST_POWERDOWN: U54.1(A) ; also on sheet 55
TPS65224_EN: Q4.2(S) R303.1 R317.1 TP81.1(TP)
VMON1: C3750.2 R5773.1 R5774.2 U56.9(VMON1)
WD_DISABLE: R281.2 R282.2 TP56.1(TP) U56.29(GPIO6)
WKUP_I2C0_SCL: R297.1 ; also on sheet 21
WKUP_I2C0_SDA: R307.1 ; also on sheet 21
ZENER_CLAMP: D2.3(C) R298.1 R308.1
N24306091: C3746.2 R293.1 U3076.5(QOD) U3076.6(OUT)
N24306103: Q4.1(G) R293.2
N24306157: D5.3(K) R308.2
N24306190: Q4.3(D) R298.2
N24307354: R5828.2 U56.4(FB_B1)
N24307356: R5829.2 U56.6(FB_B2)
N27566274: LD2.1(CATHODE) Q2.3(COLLECTOR)
N27566278: LD2.2(ANODE) R260.1
N27566306: Q2.1(BASE) R272.2
N27566380: LD4.2(ANODE) R292.1
N27566388: LD4.1(CATHODE) Q3.3(D)
N27566452: C613.2 D13.2 SW7.2
N27866324: LD6.2(ANODE) R324.1
N28129103: R5736.1 U2356.4(S2A) U2356.9(S1B)
N28224119: R297.2 U56.36(GPIO2)
N28224122: R307.2 U56.35(GPIO1)
N28389021: R5766.1 U54.4(Y) U3076.3(ON)
N29183087: Q3.1(G) R286.2

Not connected (* = marked no-connect by the designer): D2 2(NC)*; U3076 4(NC)*

## Notes on the sheets
sheet 16
- SOC POWER SUPPLY PMIC - 1
- Vz = 5V
- Route as Pseudo differential pair trace
  from Load (Remote Sense)
- (See "PCB Notes")
- FB_VDD_CORE
- FB_VDDR_CORE
- Silk: PMIC
- CAD-NOTE: TRIPAD R5747 & R5748
- PMIC uses default I2C1 ADDR: 0x28,0x29, 0x2A,0x2B
- When VDD_CORE = 0.75v,
  Depopulate R5748 & Populate R5747
- PMIC Config option
- SELx
- D1
- D2
- 0
- S1B
- S2B
- Silk: PMIC_LPM_SEL
- 1
- S1A
- S2A
- 0.495V to VMON1 pin
- Silk: PMIC_PROG
sheet 17
- SOC POWER SUPPLY PMIC - 2
- PMIC POWER INDICATION LED
- VBE = 0.85V
  Ic = 20mA
  Ib = 0.2mA
- PMIC PUSH BUTTON LOGIC
- POWER INDICATION LED:
  VCC_3V3_SYS
- Silk: PMIC_CORE_CONFIG
- Note: When R371 is DNI, Push Button (SW7) becomes
  operational through internal pullup on PMIC GPIO5
- R371
- VDD_CORE VOLTAGE
- Mounted
- 0.85 V (DEFAULT)
- Not Mounted
- 0.75 V

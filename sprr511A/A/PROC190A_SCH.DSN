# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 52 to 54 of 57

## Sheets
52 52. FT4232 UART BUFFERS: size C; title: FT4232 UART BUFFERS
53 53. XDS110 DEBUGGER: size C; title: XDS110 DEBUGGER
54 54. XDS110 JTAG BUFFER: size C; title: XDS110 JTAG BUFFER

## Parts
sheet 16. SOC POWER SUPPLIES
U136  AM275x_EVM_SoC  [BGA361_31-49_630X630_1-5]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N)
sheet 52. FT4232 UART BUFFERS
C574  0.1uF  [CAP0201_0-5]
C575  0.1uF  [CAP0201_0-5]
C608  0.1uF  [CAP0201_0-5]
C612  0.1uF  [CAP0201_0-5]
C617  0.1uF  [CAP0201_0-5]
C618  0.1uF  [CAP0201_0-5]
C3718  0.1uF  [CAP0201_0-5]
C3719  0.1uF  [CAP0201_0-5]
R322  4.7K  [RES0201_0-5]
R326  4.7K  [RES0201_0-5]
R361  4.7K  [RES0201_0-5]
R590  10K  [RES0201_0-5]
R591  10K  [RES0201_0-5]
R592  4.7K  [RES0201_0-5]
R593  4.7K  [RES0201_0-5]
R611  4.7K  [RES0201_0-5]
R612  4.7K  [RES0201_0-5]
R613  10K  [RES0201_0-5]
R614  10K  [RES0201_0-5]
R631  4.7K  [RES0201_0-5]
R635  10K  [RES0201_0-5]
R636  10K  [RES0201_0-5]
R5799  10K  [RES0201_0-5]
R5800  10K  [RES0201_0-5]
R5832  0E  [RES0402_0-5]
R5833  10K  [RES0201_0-5]
TP97  TP20_SMD  [TP20_SMD]
TP117  TP20_SMD  [TP20_SMD]
U117  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U125  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U126  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U2351  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]
U2352  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]
sheet 53. XDS110 DEBUGGER
C190  0.01uF  [CAP0201_0-5]
C203  0.1uF  [CAP0201_0-5]
C208  0.01uF  [CAP0201_0-5]
C215  0.1uF  [CAP0201_0-5]
C217  12pF  [CAP0201_0-5]
C221  0.01uF  [CAP0201_0-5]
C222  1uF  [CAP0201_0-5]
C223  12pF  [CAP0201_0-5]
C225  0.1uF  [CAP0201_0-5]
C231  0.1uF  [CAP0201_0-5]
C232  0.01uF  [CAP0201_0-5]
C233  1uF  [CAP0201_0-5]
C234  0.01uF  [CAP0201_0-5]
C240  2.2uF  [CAP0402_0-75]
C241  1uF  [CAP0201_0-5]
C243  15pF  [CAP0201_0-5]
C244  2.2uF  [CAP0402_0-75]
C250  4.7uF  [CAP0402_0-75]
C267  0.1uF  [CAP0402_0-75]
C430  0.1uF  [CAP0201_0-5]
C488  1uF  [CAP0201_0-5]
C516  0.1uF  [CAP0201_0-5]
C605  1000pF  [CAP1206_1-75]
D1  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
J17  CON_MUSB-B_5_F  [CON_MUSBB5_629105150521_S_R_S_2-7]
LD3  150040RS73220  [LED_150040GS73220_40X20_SMD_0-4]
LD5  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
R218  4.87K_1%  [RES0402_0-5]
R229  1K_1%  [RES0402_0-5]
R230  1K_1%  [RES0402_0-5]
R231  1K_1%  [RES0402_0-5]
R232  1K_1%  [RES0402_0-5]
R236  4.7K  [RES0201_0-5]
R237  4.7K  [RES0201_0-5]
R241  4.7K  [RES0201_0-5]
R246  49.9E_1%  [RES0402_0-5]
R271  0E  [RES0201_0-5]
R276  220E  [RES0402_0-5]
R287  220E  [RES0402_0-5]
R289  20K_1%  [RES0402_0-5]
R295  30K  [RES0402_0-5]
R306  51K_1%  [RES0402_0-5]
R313  30K_1%  [RES0402_0-5]
R314  0E  [RES0201_0-5]
R520  1K_1%  [RES0402_0-5]
R521  1K_1%  [RES0402_0-5]
R522  1K_1%  [RES0402_0-5]
R523  1K_1%  [RES0402_0-5]
R549  10K  [RES0201_0-5]
R556  10K  [RES0201_0-5]
R576  100E_1%  [RES0402_0-5]
R610  0E  [RES0805_0-75]
R5730  0E  [RES0201_0-5]
R5731  0E  [RES0201_0-5]
TP51  TP20_SMD  [TP20_SMD]
TP62  TP20_SMD  [TP20_SMD]
TP63  TP20_SMD  [TP20_SMD]
TP64  TP20_SMD  [TP20_SMD]
TP66  TP20_SMD  [TP20_SMD]
TP68  TP20_SMD  [TP20_SMD]
TP78  TP20_SMD  [TP20_SMD]
U41  LM4040B25IDCKR  [SC70-5_1-1]
U48  TM4C1294NCPDTT3R  [TQFP128_15-74_550X550_1-2]  (sections A,B,C)
U55  TPS79601DRBR  [SON8_25-59_130X130_1]
U60  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]
Y5  16.000MHz  [XTAL4_XRCGB-FM_80X60_SMD_0-7]
sheet 54. XDS110 JTAG BUFFER
C469  0.1uF  [CAP0201_0-5]
C470  0.1uF  [CAP0201_0-5]
C500  0.1uF  [CAP0201_0-5]
C511  0.1uF  [CAP0201_0-5]
C515  0.1uF  [CAP0201_0-5]
C528  0.1uF  [CAP0201_0-5]
R533  10K  [RES0201_0-5]
R534  10K  [RES0201_0-5]
R542  22E  [RES0201_0-5]
R544  22E  [RES0201_0-5]
R554  10K  [RES0201_0-5]
R555  10K  [RES0201_0-5]
R564  4.7K  [RES0201_0-5]
U97  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U102  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]
U109  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]

## Library data of the parts
U136 = AM275X_EVM_SOC_BGA361: IC AM275x EVM SoC BGA361; Chkd/date: PRADEEP/220524; Crtd /date: SHANKARI/210524; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Height: 1.42MM; Library Ref: AM275x_EVM_SoC_BGA361; Mfr_name: NA; Mistral Part No: 141324050006; Package: BGA361; Part_type: ICS\DIGITAL\FPGA; Project: AM275x_EVM; Remarks: FP NEED TO CHECK WITH MANUFACTURE AND CUSTOMER; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\AM275x_EVM_SoC.PDF
C203 C215 C225 C231 C430 C469 C470 C500 C511 C515 C516 C528 C574 C575 C608 C612 C617 C618 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C3718 C3719 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
R236 R237 R241 R322 R326 R361 R564 R592 R593 R611 R612 R631 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R533 R534 R549 R554-R556 R590 R591 R613 R614 R635 R636 R5799 R5800 R5833 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5832 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP51 TP62-TP64 TP66 TP97 TP117 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U97 U117 U125 U126 = SN74AVC4T245RSV_UQFN16: IC 2-BIT BUS TRANSCEIVER WITH CONFIGURABLE VOLTAGE TRANSLATION AND 3 STATE O/P UQFN16; Chkd/date: MANIRAJA/040520; Crtd /date: BAVISH/190411; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24366-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_BUSDRIVERTRANSCEIVER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011040011-R; Package: UQFN16; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: HMC; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 41mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\SN74AVC4T245-SER.PDF
U2351 U2352 = TMUX1136_USON10: IC 5V LOW-LEAKAGE-CURRENT 2:1 2-CHANNEL PRECISION ANALOG SWITCH USON10; Chkd/date: MANIRAJA/291121; Crtd /date: ALVY/291121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-TMUX1136DQARCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_ANALOG-APPLICATION_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140121110003-R; Package: USON10; Part_type: ICS\ANALOG\SWITCH; Project: TI_AM263x_CC_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 4.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ANALOG\TMUX1136.PDF
C190 C208 C221 C232 C234 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
C217 C223 = CAP: CAP CERAMIC 12pF 25V 5% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E120JA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E120JA02D; Mistral Part No: 120021120012-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E120JA02.PDF
C222 C233 C241 C488 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C240 C244 = CAP: CAP CERAMIC 2.2uF 25V 10% X5R AUTO 0402; Chkd/date: MANIRAJA/240920; Crtd /date: ALVY/240920; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12267-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61E225KE13D; Mistral Part No: 120020090019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: ECU_RO; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61E225KE13.PDF
C243 = CAP: CAP CERAMIC 15pF 25V 2% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E150GA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E150GA02D; Mistral Part No: 120021120013-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 2%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E150GA02.PDF
C250 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R61A475ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61A475ME13D; Mistral Part No: 120021020032-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61A475ME13.PDF
C267 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C605 = CAP: CAP CERAMIC 1000pF 2KV 10% X7R 1206; Chkd/date: SHREESHAIL/291106; Crtd /date: MAZHAR/281106; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-2956-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.52MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 1206GC102KAT1A; Mistral Part No: 120015080006-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 2KV; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_HV-MLC.PDF
D1 = DIODE_SOD323: DIODE 1CH ESD PROTECTION X1SON2; Chkd/date: MANIRAJA/040420; Crtd /date: VASANTHA/181114; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30406-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130014110022-R; Package: X1SON2; Part_type: DIODE; Project: GALILEO_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD1E10B06-SER.PDF
J17 = CON_USB_MINI-B: CON MICRO USB TYPE B 5POS FEMALE RT SMD; Chkd/date: MANIRAJA/150519; Crtd /date: ALVY/150519; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5960-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.66MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 629105150521; Mistral Part No: 150019050015-R; Package: SMD; Part_type: CONNECTOR\USB; Project: NEXTNAV_ALT-STATION_ATE_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 360mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\629105150521.PDF
LD3 = DIODE_LED: DIODE LED RED SMD; Chkd/date: MANIRAJA/100920; Crtd /date: ALVY/100920; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-13422-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020090020-R; Package: SMD; Part_type: OPTO\LED; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 29.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150040RS73220.PDF
LD5 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
R218 = RESISTOR: RES 4.87K 1/10W 1% 0402; Chkd/date: MAZHAR/150709; Crtd /date: USMAN/150109; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P4.87KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF4871X; Mistral Part No: 110009030803-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: BSN-II; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R229-R232 R520-R523 = RESISTOR: RES 1K 1/10W 1% 0402; Chkd/date: VASANTHA/281216; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.00KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1001X; Mistral Part No: 110009030411-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R246 = RESISTOR: RES 49.9E 1/16W 1% 0402; Chkd/date: MANIRAJA/210519; Crtd /date: MANIRAJA/210519; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-3967-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040249R9FKEDC; Mistral Part No: 110009030846-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RFSU_RFTJ_CARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW_C-SER.PDF
R271 R314 R5730 R5731 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R276 R287 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R289 = RESISTOR: RES 20K 1/16W 1% 0402; Chkd/date: MANIRAJA/021120; Crtd /date: MANIRAJA/021120; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-20.0KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040220K0FKED; Mistral Part No: 110009030486-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VAGG_SBC_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R295 = RESISTOR: RES 30K 1/16W 5% 0402; Chkd/date: MANIRAJA/230817; Crtd /date: MANIRAJA/230817; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-30KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040230K0JNED; Mistral Part No: 110017080023-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R306 = RESISTOR: RES 51K 1/16W 1% 0402; Chkd/date: MANIRAJA/110918; Crtd /date: ALVY/100918; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-51.0KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0751KL; Mistral Part No: 110014060030-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: NARL_DRSP_4CH; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R313 = RESISTOR: RES 30K 1/16W 1% 0402; Chkd/date: MAZHAR/130709; Crtd /date: USMAN/060109; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-30.0KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040230K0FKED; Mistral Part No: 110009030672-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: OMAP_EVM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R576 = RESISTOR: RES 100E 1/16W 1% 0402; Chkd/date: MANIRAJA/060318; Crtd /date: NAVEED/220714; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100LRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-07100RL; Mistral Part No: 110014070015-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: DLRU; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R610 = RESISTOR: RES 0E 1/8W 5% 0805; Chkd/date: VASANTHA/130416; Crtd /date: JEBRAN/020316; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0ARCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0805JR-070RL; Mistral Part No: 110009030074-R; Package: 0805; Part_type: RESISTORS\FIXED; Project: ZK_BIOMETRIC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/8W; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP68 TP78 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Manufacturer: LOCAL; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U41 = LM4040B25IDCKR_SC70-5: IC PRECISION MICROPOWER SHUNT VOLTAGE REFERENCE SC70-5; Chkd/date: MANIRAJA/230817; Crtd /date: MANIRAJA/230817; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-20873-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142017080015-R; Package: SC70-5; Part_type: ICS\POWER\VOLTAGE REGULATOR; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 30mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\LM4040B25I.PDF
U48 = TM4C1294NCPDTT3R_TQFP128: IC 32-BIT MICROCONTROLLER WITH 1MB FLASH TQFP128; Chkd/date: MANIRAJA/220817; Crtd /date: MANIRAJA/220817; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: TM4C1294NCPDTT3R-ND; Height: 1.20MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141217080002-R; Package: TQF9128; Part_type: ICS\DIGITAL\MICROCONTROLLER; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 503.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\TM4C1294NCPD.PDF
U55 = TPS79601DRBR_SON8: IC 1A HIGH PSRR RF ADJ LDO LINEAR REGULATOR SON8; Chkd/date: MANIRAJA/030518; Crtd /date: MAZHAR/280809; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-23107-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142009080012-R; Package: SON8; Part_type: ICS\POWER\VOLTAGE REGULATOR; Project: DIO_TXRX; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 24mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\REGULATORS\TPS796XX.PDF
U60 = TPD4E004_SON6: IC 4-CH ESD PROTECTION ARRAY FOR HIGH SPEED DATA INTERFACE SON6; Chkd/date: MANIRAJA/100320; Crtd /date: MUDDU/010310; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-23618-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141010020012-R; Package: SON6; Part_type: ICS\INTERFACE; Project: BUG_BASE-II; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 3.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD4E004-SER.PDF
Y5 = CRY4_13: CRY 16.000MHz 8pF SMD; Chkd/date: MANIRAJA/151020; Crtd /date: ALVY/151020; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 490-18283-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: XRCGB16M000FXN01R0; Mistral Part No: 130020100044-R; Package: SMD; Part_type: CRYSTAL; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -30°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 195.4mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\XRCGB16M000FXN01R0.PDF
R542 R544 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
U102 = TXS0102DQX_SON8: IC 2-BIT BI-DIR VOLTAGE-LEVEL TRANSLATOR FOR OPEN-DRAIN AND PUSH-PULL X2SON8; Chkd/date: MANIRAJA/010719; Crtd /date: CHAITHANYA230512; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-28368-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141012050010-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: GEN_3-8_DB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXS0102-SER.PDF
U109 = SN74AVC2T244DQMR_X2SON8: IC 2-BIT UNDIRECTIONAL VOLTAGE-LEVEL TRANSLATOR X2SON8; Chkd/date: VASANTHA/060516; Crtd /date: VASANTHA/030316; Customs_HS_Code: 15%; Distributor_name: DIGIKEY; Distributor_part_number: 296-29674-1-ND; Height: 0.40MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016030002-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Pb-Free: 85423100; Project: OCTASIC_3600; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\SN74AVC2T244.PDF

## Nets
DGND: C190.2 C203.1 C208.2 C215.1 C217.1 C221.2 C222.2 C223.1 C225.1 C231.1 C232.2 C233.2 C234.2 C240.2 C241.2 C244.2 C250.2 C267.2 C430.1 C469.1 C470.1 C488.2 C500.1 C511.1 C515.1 C516.1 C528.1 C574.1 C575.1 C605.1 C608.1 C612.1 C617.1 C618.1 C3718.2 C3719.2 D1.1 J17.5(GND) LD3.1(CATHODE) LD5.1(CATHODE) R218.2 R229.1 R230.1 R231.1 R232.1 R289.2 R313.2 R555.1 R556.2 R564.2 R591.1 R610.1 R613.1 R635.1 R5799.1 R5800.1 R5833.2 U41.1(ANODE) U48.10(GNDA) U48.17(GND) U48.48(GND) U48.55(GND) U48.58(GND) U48.64(~{WAKE}) U48.66(XOSC0) U48.80(GND) U48.114(GND) U55.6(GND) U55.9(PAD) U60.3(GND) U97.10(GND1) U97.11(GND2) U102.4(GND) U109.3(A2) U109.5(GND) U109.6(B2) U117.1(~{1OE}) U117.10(GND1) U117.11(GND2) U117.16(~{2OE}) U125.7(1A2) U125.9(2A2) U125.10(GND1) U125.11(GND2) U125.12(2B2) U125.14(1B2) U126.1(~{1OE}) U126.7(1A2) U126.9(2A2) U126.10(GND1) U126.11(GND2) U126.12(2B2) U126.14(1B2) U126.16(~{2OE}) U2351.3(GND) U2352.3(GND) Y5.2 Y5.4 ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 55 56
VCC1V8_SYS: C470.2 C511.2 C528.2 C608.2 C617.2 C3718.1 C3719.1 R361.1 R533.2 R534.2 R554.2 R611.1 R612.1 R614.2 R631.1 R636.2 U97.3(VCCA) U102.1(VCCA) U109.1(VCCA) U125.3(VCCA) U126.3(VCCA) U2351.8(VDD) U2352.8(VDD) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 38 39 40 42 43 44 46 47 48 56
VCC3V3_XDS: C208.1 C221.1 C222.1 C231.2 C232.1 C234.1 C241.1 C243.1 C430.2 C469.2 C488.1 C500.2 C515.2 R236.1 R237.1 R241.1 R246.2 R306.1 R520.2 R521.2 R522.2 R523.2 R549.2 TP68.1(TP) U48.7(VDD) U48.8(VDDA) U48.16(VDD) U48.26(VDD) U48.28(VDD) U48.39(VDD) U48.47(VDD) U48.51(VDD) U48.52(VDD) U48.69(VDD) U48.79(VDD) U48.90(VDD) U48.101(VDD) U48.113(VDD) U48.122(VDD) U55.3(OUT1) U55.4(OUT2) U97.2(VCCB) U102.8(VCCB) U109.8(VCCB) ; also on sheet 31 46 55
VCC_3V3_FT4232: C575.2 C612.2 C618.2 U117.2(VCCB) U125.2(VCCB) U126.2(VCCB) ; also on sheet 51
VDDC_1V2: C233.1 C240.1 C516.2 U48.87(VDDC) U48.115(VDDC)
VDDSHV_CANUART: C574.2 R322.1 R326.1 R590.2 R592.1 R593.1 U117.3(VCCA) ; also on sheet 14 15 16 17 23 24 45 46
BUF_BOOTMODE_I2C0_SCL: U48.82(PL1) ; also on sheet 55
BUF_BOOTMODE_I2C0_SDA: U48.81(PL0) ; also on sheet 55
BUF_BOOTMODE_I2C_SCL: U48.49(PG0) ; also on sheet 46
BUF_BOOTMODE_I2C_SDA: U48.50(PG1) ; also on sheet 46
BUF_TEST_GPIO1: U48.74(PM4) ; also on sheet 55
BUF_TEST_GPIO2: U48.73(PM5) ; also on sheet 55
BUF_TEST_GPIO3: U48.72(PM6) ; also on sheet 55
BUF_TEST_GPIO4: U48.71(PM7) ; also on sheet 55
BUF_TEST_PORZn: U48.77(PM1) ; also on sheet 55
BUF_TEST_POWERDOWN: U48.78(PM0) ; also on sheet 55
BUF_TEST_WARMRESETn: U48.76(PM2) ; also on sheet 55
FT4232_SOC_UART2_RX_3V3: U125.13(2B1) ; also on sheet 51
FT4232_SOC_UART2_TX_3V3: U125.15(1B1) ; also on sheet 51
FT4232_SOC_UART3_RX_3V3: U126.13(2B1) ; also on sheet 51
FT4232_SOC_UART3_TX_3V3: U126.15(1B1) ; also on sheet 51
FT4232_UART2_RXD_1V8: R612.2 U125.8(2A1) U2351.7(S2B)
FT4232_UART2_TXD_1V8: R611.2 U125.6(1A1) U2351.9(S1B)
FT4232_UART3_RXD_1V8: R361.2 TP97.1(TP) U126.8(2A1) U2352.7(S2B)
FT4232_UART3_TXD_1V8: R631.2 TP117.1(TP) U126.6(1A1) U2352.9(S1B)
FT4232_WKUP_UART0_CTSN_3V3: U117.12(2B2) ; also on sheet 51
FT4232_WKUP_UART0_RTSN_3V3: U117.14(1B2) ; also on sheet 51
FT4232_WKUP_UART0_RXD_3V3: U117.13(2B1) ; also on sheet 51
FT4232_WKUP_UART0_TXD_3V3: U117.15(1B1) ; also on sheet 51
OSC0: C217.2 U48.88(OSC0) Y5.3
OSC1: C223.2 U48.89(OSC1) Y5.1
RESETSTATZ_1V8_INV: R5832.1 ; also on sheet 23
SEL_XDS: U97.1(~{1OE}) U97.16(~{2OE}) U109.4(~{OE}) ; also on sheet 56
SEL_XDS110_INV: U102.5(OE) ; also on sheet 56
SoC_EMU0: U102.2(A1) U136.C9(EMU0) ; also on sheet 56
SoC_EMU1: U102.3(A2) U136.C10(EMU1) ; also on sheet 56
SoC_TCK: R534.1 R544.1 U136.A10(TCK) ; also on sheet 56
SoC_TDI: R554.1 U97.6(1A1) U136.D10(TDI) ; also on sheet 56
SoC_TDO: R542.1 U109.2(A1) ; also on sheet 56
SoC_TMS: R533.1 U97.8(2A1) U136.C11(TMS) ; also on sheet 56
SoC_TRST#: R564.1 U97.9(2A2) U136.B10(TRSTn) ; also on sheet 56
SOC_UART0_RXD_XDS: R5730.1 ; also on sheet 31
SOC_UART0_TXD_XDS: R5731.1 ; also on sheet 31
TM4C129_TCK: TP66.1(TP) U48.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP64.1(TP) U48.98(PC2/TDI)
TM4C129_TDO: TP62.1(TP) U48.97(PC3/TDO/SWO)
TM4C129_TMS: TP63.1(TP) U48.99(PC1/TMS/SWDIO)
UART2_FET_SEL: R5799.2 U2351.1(SEL1) U2351.5(SEL2) ; also on sheet 47
UART2_RXD: U2351.4(S2A) ; also on sheet 42
UART2_RXD_FET: U2351.6(D2) ; also on sheet 25 30
UART2_TXD: U2351.2(S1A) ; also on sheet 42
UART2_TXD_FET: U2351.10(D1) ; also on sheet 31
UART3_FET_SEL: R5800.2 U2352.1(SEL1) U2352.5(SEL2) ; also on sheet 47
UART3_RXD: U2352.4(S2A) ; also on sheet 43
UART3_RXD_FET: U2352.6(D2) ; also on sheet 21
UART3_TXD: U2352.2(S1A) ; also on sheet 43
UART3_TXD_FET: U2352.10(D1) ; also on sheet 31
WKUP_UART0_CTSN: R322.2 U117.9(2A2) ; also on sheet 21
WKUP_UART0_RTSN: R593.2 U117.7(1A2) ; also on sheet 21
WKUP_UART0_RXD: R326.2 U117.8(2A1) ; also on sheet 21
WKUP_UART0_TXD: R592.2 U117.6(1A1) ; also on sheet 21
XDS110_DIR: R555.2 U97.4(1DIR) U97.5(2DIR)
XDS110_EMU0: R237.2 U48.42(PF0) U102.7(B1)
XDS110_EMU1: R236.2 U48.43(PF1) U102.6(B2)
XDS110_TCK: U48.35(PA2/SSI0CLK) U97.14(1B2)
XDS110_TDI: U48.38(PA5/SSI0XDAT1) U97.15(1B1)
XDS110_TDO: U48.37(PA4/SSI0XDAT0) U109.7(B1)
XDS110_TMS: U48.36(PA3/SSI0FSS) U97.13(2B1)
XDS110_TRST#: U48.40(PA6) U97.12(2B2)
XDS_RSTn: R549.1 R556.1 TP51.1(TP) U48.70(~{RST})
XDS_SHIELD: C605.2 J17.6(SH1) J17.7(SH2) J17.8(SH3) J17.9(SH4) R610.2
XDS_USB_DM: J17.2(D-) U48.93(PL7/USB0DM)
XDS_USB_DP: J17.3(D+) U48.94(PL6/USB0DP)
XDS_USB_ID: J17.4(ID) R271.2 U60.2(IO2)
XDS_USB_VBUS: C244.1 C250.1 C267.1 D1.2 J17.1(VBUS) R295.1 R314.1 R576.1 TP78.1(TP) U55.1(IN1) U55.2(IN2) U60.6(VCC)
XDS_VREF: C190.1 C215.2 R241.2 U41.3(CATHODE) U48.9(VREFA+)
N16997746: R218.1 U48.59(RBAIS)
N17030208: R544.2 U97.7(1A2)
N17479799: R314.2 U55.8(EN)
N17479805: C243.2 R306.2 R313.1 U55.5(NR/FB)
N17479881: C203.2 R246.1 U48.68(VBAT)
N17481587: LD5.2(ANODE) R287.2
N17481598: C225.2 R576.2 U48.96(PB1/USB0VBUS)
N17481613: R271.1 U48.95(PB0/USB0ID)
N17481619: R289.1 R295.2 U48.1(PD0/AIN15)
N17481621: R232.2 R520.1 U48.60(PK7)
N17481627: R276.1 U48.3(PD2/AIN13)
N17481631: LD3.2(ANODE) R276.2
N17481633: R229.2 R523.1 U48.63(PK4)
N17481635: R231.2 R521.1 U48.61(PK6)
N17481637: R287.1 U48.4(PD3/AIN12)
N17481641: R230.2 R522.1 U48.62(PK5)
N27239473: R591.2 U117.5(2DIR)
N27239479: R590.1 U117.4(1DIR)
N27239774: R5832.2 R5833.1 U125.1(~{1OE}) U125.16(~{2OE})
N27239926: R635.2 U126.5(2DIR)
N27239932: R636.1 U126.4(1DIR)
N27240077: R613.2 U125.5(2DIR)
N27240083: R614.1 U125.4(1DIR)
N28118724: R5730.2 U48.33(PA0/U0RX)
N28118727: R5731.2 U48.34(PA1/U0TX)
N28122339: R542.2 U136.A11(TDO)

Not connected (* = marked no-connect by the designer): U41 2(NC1)* 4(NC2)* 5(NC3)*; U48 2(PD1/AIN14)* 5(PQ0)* 6(PQ1)* 11(PQ2)* 12(PE3/AIN0)* 13(PE2/AIN1)* 14(PE1/AIN2)* 15(PE0/AIN3)* 18(PK0/AIN16)* 19(PK1/AIN17)* 20(PK2/AIN18)* 21(PK3/AIN19)* 22(PC7/C0-)* 23(PC6/C0+)* 24(PC5/C1+)* 25(PC4/C1-)* 27(PQ3)* 29(PH0)* 30(PH1)* 31(PH2)* 32(PH3)* 41(PA7)* 44(PF2)* 45(PF3)* 46(PF4)* 53(EN0RXIN)* 54(EN0RXIP)* 56(EN0RX0N)* 57(EN0RX0P)* 65(~{HIB})* 67(XOSC1)* 75(PM3)* 83(PL2)* 84(PL3)* 85(PL4)* 86(PL5)* 91(PB2/I2C0SCL)* 92(PB3/I2C0SDA)* 102(PQ4)* 103(PP2)* 104(PP3)* 105(PP4)* 106(PP5)* 107(PN0)* 108(PN1)* 109(PN2)* 110(PN3)* 111(PN4)* 112(PN5)* 116(PJ0)* 117(PJ1)* 118(PP0/C2+)* 119(PP1/C2-)* 120(PB5/AIN11)* 121(PB4/AIN10)* 123(PE4/AIN9)* 124(PE5/AIN8)* 125(PD4/AIN7)* 126(PD5/AIN6)* 127(PD6/AIN5)* 128(PD7/AIN4)*; U55 7(NC)*; U60 1(IO1)* 4(IO3)* 5(IO4)*

## Notes on the sheets
sheet 52
- FT4232 UART BUFFERS
- SELx
- D1
- D2
- 0
- (DEFAULT)
- S1B
- S2B
- 1
- S1A
- S2A
- SELx
- D1
- D2
- 0
- (DEFAULT)
- S1B
- S2B
- 1
- S1A
- S2A
sheet 53
- XDS110 DEBUGGER
- SILK SCREEN : VCC3V3_XDS
- SILK SCREEN : XDS_USB_VBUS
- Silk: JTAG
- GREEN
- RED
- Sets the unique ID of the Debugger
- TEST AUTOMATION GPIO MAPPING
- Internal/
  External
  PU/PD states
- SIGNAL NAME
- DESCRIPTION
- Direction WRT CTRL
- OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
- TEST_POWERDOWN
  TEST_PORZn
  TEST_WARMRESETn
  TEST_GPIO1
  TEST_GPIO2
  TEST_GPIO3
  TEST_GPIO4
- Used to Power down the EVM
  Used to  Reset the SoC PORz
  Used to Reset the SoC Warmreset
  Used to Generate the interrupt on
  SOC_GPIO0_90 Pin
  Connected to IO Expander to Communicate with SOC
  Used to Enable the BOOTMODE Buffer
  Used to Reset the Bootmode I2C IO Expander
- External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
sheet 54
- SOC - JTAG
- XDS110 JTAG BUFFER
- XDS110_DIR = H: A -> B
  XDS110_DIR = L: B -> A
  OE = H: output = Hi-Z

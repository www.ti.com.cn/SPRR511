# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 13 to 15 of 57

## Sheets
13 11. USB TYPE-C POWER CONNECTOR: size C; title: USB TYPE-C POWER CONNECTOR
14 12. PERIPHERAL POWER SUPPLY: size C; title: PERIPHERAL POWER SUPPLY
15 13. PRE REGULATOR SUPPLY - LDOs: size C; title: SOC POWER SUPPLIES - LDOs  & VCC_3V3_SYS LOAD SWITCH

## Parts
sheet 11. USB TYPE-C POWER CONNECTOR
C300  0.01uF  [CAP0201_0-5]
C302  10uF  [CAP0603_1]
C308  330pF  [CAP0402_0-75]
C310  1uF  [CAP0402_0-75]
C326  0.01uF  [CAP0201_0-5]
C327  0.01uF  [CAP0201_0-5]
C648  1000pF  [CAP1206_1-75]
C654  0.01uF  [CAP0201_0-5]
C655  0.01uF  [CAP0201_0-5]
D7  TPD1E01B04DPLT  [DIO_DFN0201_0-4]
D17  TPD1E01B04DPLT  [DIO_DFN0201_0-4]
J24  CON_USB-C_24_F  [CON_USBC24_2012670_S_R_S_3-9]
LD13  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
LD14  150040RS73220  [LED_150040GS73220_40X20_SMD_0-4]
R195  470E  [RES0402_0-5]
R381  10K  [RES0201_0-5]
R382  0E  [RES0402_0-5]
R395  0E  [RES0603_0-75]
R404  0E  [RES0603_0-75]
R3933  470E  [RES0402_0-5]
R5767  10K  [RES0201_0-5]
TP107  TP20_SMD  [TP20_SMD]
U71  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]
U73  TPS22810DRVT  [SON6_25-59_85X85_0-8]
U133  TVS2200DRVR  [SON6_25-59_85X85_0-8]
sheet 12. PERIPHERAL POWER SUPPLY
C3494  0.1uF  [CAP0402_0-75]
C3497  0.1uF  [CAP0402_0-75]
C3625  10uF  [CAP1206_2]
C3627  10uF  [CAP0402_0-75]
C3628  10uF  [CAP1206_2]
C3629  0.22uF  [CAP0603_1]
C3630  0.22uF  [CAP0603_1]
C3631  0.1uF  [CAP0402_0-75]
C3636  47uF  [CAP1206_2]
C3637  47uF  [CAP1206_2]
C3638  47uF  [CAP1206_2]
C3639  33pF  [CAP0402_0-75]
L24  6.8uH  [IND_XAL8080_330X350_SMD_8]
R3028  10K  [RES0402_0-5]
R3651  24.9K_1%  [RES0402_0-5]
R3652  33K_1%  [RES0603_0-75]
R3653  10K  [RES0402_0-5]
R3661  1K  [RES0201_0-5]
R3720  100K  [RES0402_0-5]
R3727  100K  [RES0402_0-5]
R5740  10K  [RES0402_0-5]
R5805  0E  [RES0201_0-5]
TP1  THRU HOLE  [TP_40X65]
TP2  THRU HOLE  [TP_40X65]
TP40  THRU HOLE  [TP_40X65]
TP41  TP40_SMD  [TP40_SMD]
TP42  TP40_SMD  [TP40_SMD]
TP44  TP40_SMD  [TP40_SMD]
TP77  THRU HOLE  [TP_40X65]
TP85  THRU HOLE  [TP_40X65]
TP103  TP20_SMD  [TP20_SMD]
TP104  TP20_SMD  [TP20_SMD]
U134  LM61460AASQRJRRQ1  [VQFNHR14_LM61460_160X140_1]
sheet 13. PRE REGULATOR SUPPLY - LDOs
C197  1uF  [CAP0201_0-5]
C207  1uF  [CAP0201_0-5]
C247  2.2uF  [CAP0201_0-75]
C251  0.1uF  [CAP0201_0-5]
C255  1uF  [CAP0201_0-5]
C3642  0.01uF  [CAP0201_0-5]
C3643  1uF  [CAP0402_0-75]
C3644  2.2uF  [CAP0201_0-75]
R240  10K  [RES0201_0-5]
R255  100K_1%  [RES0402_0-5]
R258  182K_1%  [RES0402_0-5]
R304  0E  [RES0603_0-75]
R319  0E  [RES0201_0-5]
R320  10K  [RES0201_0-5]
R3723  47.5K_1%  [RES0402_0-5]
R3724  21K_1%  [RES0402_0-5]
R3725  10K  [RES0201_0-5]
R3726  10K  [RES0201_0-5]
R5786  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
R5787  0.01E_1%  [RES_KRL3216T4_1206-4_0-7]
TP52  TP20_SMD  [TP20_SMD]
TP69  TP20_SMD  [TP20_SMD]
TP597  TP20_SMD  [TP20_SMD]
U46  TLV75801PDBVT  [SOT23-5_1-5]
U59  TPS7A2118PQWDRBRQ1  [SON8_25-59_130X130_1]
U135  TPS74601PDRVR  [SON6_25-59_85X85_0-8]

## Library data of the parts
C300 C326 C327 C654 C655 C3642 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
C302 = CAP: CAP CERAMIC 10uF 25V 20% X5R AUTO 0603; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT188R61E106ME13; Mistral Part No: 120022060023-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT188R61E106ME13.PDF
C308 = CAP: CAP CERAMIC 330pF 50V 5% C0G(NP0) AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT1555C1H331JA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT1555C1H331JA02D; Mistral Part No: 120019050019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT1555C1H331JA02.PDF
C310 C3643 = CAP: CAP CERAMIC 1uF 25V 10% X6S AUTO 0402; Chkd/date: MANIRAJA/270520; Crtd /date: ALVY/260520; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-18215-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155C81E105KE13D; Mistral Part No: 120020050024-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DARE_ECU_MCB; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 1.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155C81E105KE13.PDF
C648 = CAP: CAP CERAMIC 1000pF 2KV 10% X7R 1206; Chkd/date: SHREESHAIL/291106; Crtd /date: MAZHAR/281106; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-2956-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.52MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 1206GC102KAT1A; Mistral Part No: 120015080006-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 2KV; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_HV-MLC.PDF
D7 D17 = DIODE_TVS_DUAL: DIODE 1CH ESD PROTECTION FOR USB TYPE-C AND THUNDERBOLT3 X2SON2; Chkd/date: MANIRAJA/230920; Crtd /date: ALVY/230920; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: 296-44484-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.32MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130020090037-R; Package: X2SON2; Part_type: DIODE\TVS; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\TPD1E01B04.PDF
J24 = CON_USB-C_24_1240183621: CON USB-C TYPE 24POS FEMALE RT SMD; Chkd/date: MANIRAJA/050618; Crtd /date: ALVY/040618; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM17992CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 3.86MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 2012670005; Mistral Part No: 150018060002-R; Package: SMD; Part_type: CONNECTOR\USB; Project: TI_J7SVB_USB_ADD-ON-CARD; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.686g; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\2012670X.PDF
LD13 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
LD14 = DIODE_LED: DIODE LED RED SMD; Chkd/date: MANIRAJA/100920; Crtd /date: ALVY/100920; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-13422-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020090020-R; Package: SMD; Part_type: OPTO\LED; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 29.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150040RS73220.PDF
R195 R3933 = RESISTOR: RES 470E 1/10W 5% 0402; Chkd/date: SHREESHAIL/24050; Crtd /date: MAZHAR/260706; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P470JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ471X; Mistral Part No: 110009030859-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: POWERBOX; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R240 R320 R381 R3725 R3726 R5767 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R382 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R395 R404 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: PANASONIC-ECG; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP52 TP103 TP104 TP107 TP597 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U71 = SN74LVC1G32_X2SON5: IC SINGLE 2-INPUT POSITIVE-OR GATE X2SON5; Chkd/date: MANIRAJA/141020; Crtd /date: ALVY/131020; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-SN74LVC1G32DPWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141020100011-R; Package: X2SON5; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G32XX.PDF
U73 = TPS22810DRVT_WSON6: IC 2.7-18V 3A 79mE ON RESISTANCE LOAD SWITCH WITH THERMAL PROTECTION WSON6; Chkd/date: VASANTHA/300518; Crtd /date: ALVY/290518; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-46947-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142018050016-R; Package: WSON6; Part_type: ICS\POWER\CONTROL; Project: TI_J7SVB_PCIE_ADD-ON-CARD; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS22810.PDF
U133 = TVS2200_WSON6: IC 22V FLAT-CLAMP SURGE PROTECTION DEVICE WSON6; Chkd/date: MANIRAJA/011021; Crtd /date: ALVY/011021; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-52187-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142021100001-R; Package: WSON6; Part_type: ICS\POWER; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 12mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TVS2200.PDF
C3494 C3497 = CAP: CAP CERAMIC 0.1uF 16V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B1X7R1C104K050BC; Chkd/date: NAVEED/021014; Crtd /date: VASANTHA/300514; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: MURATA; Direct Alternate_mfr_part_number: GCM155R71C104JA55D; Distributor_name: DIGIKEY; Distributor_part_number: 490-4759-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCM155R71C104KA55D; Mistral Part No: 120016070006-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DCMIST_FPGA_CARD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GCM-SER.PDF
C3625 C3628 = CAP: CAP CERAMIC 10uF 50V 10% X5R AUTO 1206; Chkd/date: MANIRAJA/261018; Crtd /date: ALVY/261018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12456-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT31CR61H106KE01L; Mistral Part No: 120011060019-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: LRDE_ABCMV2_MB; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT31CR61H106KE01L.PDF
C3627 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C3629 C3630 = CAP: CAP CERAMIC 0.22uF 50V 10% X7R AUTO 0603; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA3EX7R1H224K080AB; Chkd/date: RAGESH/290910; Crtd /date: MAZHAR/110909; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: CGA3E3X7R1H224K080AB; Distributor_name: DIGIKEY; Distributor_part_number: 490-5402-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCM188R71H224KA64; Mistral Part No: 120009090008-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: ADE POWER SUPPLY; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GCM-SER.PDF
C3631 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C3636-C3638 = CAP: CAP CERAMIC 47uF 25V 20% X5R 1206; Chkd/date: VASANTHA/261214; Crtd /date: USMAN/160513; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 445-8047-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TDK CORPORATION; Mfr_part_number: C3216X5R1E476M160AC; Mistral Part No: 120013050002-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ERP; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\TDK_C-SER-JUL17.PDF
C3639 = CAP: CAP CERAMIC 33pF 50V 5% HI-Q C0G(NP0) AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-17458-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCQ1555C1H330JB01D; Mistral Part No: 120021020039-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GCQ1555C1H330JB01.PDF
L24 = INDUCTOR: IND POWER 6.8uH 11.3A 20% SMD; Chkd/date: ALVY/040221; Crtd /date: MANIRAJA/030221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: MOUSER; Distributor_part_number: 994-XAL8080-682MEB; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: COILCRAFT; Mfr_part_number: XAL8080-682MEB; Mistral Part No: 130021020022-R; Package: SMD; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: 20%; Voltage: NA; Wattage: NA; Weight: 3000mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\XAL8080-SER.PDF
R3028 R3653 R5740 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3651 = RESISTOR: RES 24.9K 1/16W 1% 0402; Chkd/date: MANIRAJA/080520; Crtd /date: ALVY/070520; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-24.9KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040224K9FKED; Mistral Part No: 110009030538-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM64x-GP_EVM BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R3652 = RESISTOR: RES 33K 1/10W 1% 0603; Chkd/date: MANIRAJA/100118; Crtd /date: ALVY/100118; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-33.0KHRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0603FR-0733KL; Mistral Part No: 110014070055-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: DRDL_ITS2_RO-PC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3661 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3720 R3727 = RESISTOR: RES 100K 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ104X; Mistral Part No: 110009030177-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R319 R5805 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP1 TP2 TP40 TP77 TP85 = TESTPOINT: TESTPOINT 1.0MM DRILL PTH; Chkd/date: MAZHAR/271211; Crtd /date: SHREESHAIL/041005; Distributor_name: NA; Distributor_part_number: NA; Height: NA; Mfr_name: LOCAL; Mistral Part No: 130009030938; Package: THRU-HOLE; Project: HSE; Datasheet: NA
TP41 TP42 TP44 = TESTPOINT: TESTPOINT CIR 40 SMD; Chkd/date: MAZHAR/190505; Crtd /date: MAZHAR/190505; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030933; Package: SMD; Project: RAINIER-3; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U134 = LM61460_VQFNHR14: IC 6A ADJ AUTO LOW EMI SYNCHRONOUS STEP DOWN DC-DC CONVERTER VQFN-HR14; Chkd/date: ALVY/281021; Crtd /date: MANIRAJA/281021; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-LM61460AASQRJRRQ1CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142021100017-R; Package: VQFN-HR14; Part_type: ICS\POWER\DC-DC CONVERTER; Project: TI_TMDS64SKEVM_BRD; RoHS: RoHS; Temperature: -40°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 30.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\LM61460-Q1.PDF
C197 C207 C255 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C247 C3644 = CAP: CAP CERAMIC 2.2uF 10V 20% X5R 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM035R61A225ME01; Mistral Part No: 120022060026-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM035R61A225ME01.PDF
C251 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
R255 = RESISTOR: RES 100K 1/10W 1% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/130306; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1003X; Mistral Part No: 110009030187-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: J32; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R258 = RESISTOR: RES 182K 1/16W 1% 0402; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: YAG3015CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-07182KL; Mistral Part No: 110022010016-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R304 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3723 = RESISTOR: RES 47.5K 1/16W 1% 0402; Chkd/date: VASANTHA/230117; Crtd /date: MANIRAJA/110117; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-47.5KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0747K5L; Mistral Part No: 110017010006-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: DC-HSDA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3724 = RESISTOR: RES 21K 1/16W 1% 0402; Chkd/date: MANIRAJA/200319; Crtd /date: MANIRAJA/200319; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-21.0KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0721KL; Mistral Part No: 110015080019-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: OCTASIC_3000; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5786 R5787 = RESISTOR-4TERM: RES 0.01E 1W 1% 1206-4; Chkd/date: MANIRAJA/060318; Crtd /date: MANIRAJA/060318; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 408-1974-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: SUSUMU; Mfr_part_number: KRL3216T4A-M-R010-F-T1; Mistral Part No: 110018030003-R; Package: 1206-4; Part_type: RESISTORS\FIXED; Project: GRACO SMART MODULE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1W; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\KRL-SERIES.PDF
TP69 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Manufacturer: LOCAL; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U46 = TLV75801P_SOT23-5: IC 500mA ADJ LDO REGULATOR SOT23-5; Chkd/date: PRAVEEN/220922; Crtd /date: PRAVEEN/220922; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-TLV75801PDBVTCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142022090041-R; Package: SOT23-5; Part_type: ICS\POWER\VOLTAGE REGULATOR; Project: TRINETRA MISTRAL-DF; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TLV75801PXXX.PDF
U59 = TPS7A21_SON8: IC 500MA, LOW-NOISE, LOW-IQ, HIGH-PSRR LDO SON8; Chkd/date: PRADEEP/010424; Crtd /date: TAMILARASU/010424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-TPS7A2118PQWDRBRQ1CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140124040001-R; Package: SON8; Part_type: ICS\INTERFACE; Project: AM62L_EVM; RoHS: RoHS; Temperature: -40°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\TPS7A2118PQWDRBRQ1.PDF
U135 = TPS74501_WSON6: IC 1A ADJ OUTPUT LDO WITH POWER-GOOD WSON6; Chkd/date: MANIRAJA/060619; Crtd /date: ALVY/060619; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: MOUSER; Distributor_part_number: 595-TPS74601PDRVR; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142019060004-R; Package: WSON6; Part_type: ICS\POWER\VOLTAGE REGULATOR; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS74601.PDF

## Nets
DGND: C197.2 C207.2 C247.1 C251.1 C255.2 C300.1 C302.2 C308.2 C310.2 C326.2 C327.2 C648.2 C654.2 C655.2 C3497.2 C3625.2 C3627.1 C3628.2 C3629.2 C3630.2 C3631.2 C3636.2 C3637.2 C3638.2 C3642.2 C3643.2 C3644.1 D7.2(ANODE) D17.2(ANODE) J24.A1(GND) J24.A12(GND) J24.B1(GND) J24.B12(GND) LD13.1(CATHODE) R258.2 R320.2 R381.2 R404.2 R3651.2 R3652.2 R3724.2 R3727.1 R5767.2 TP1.1(TP) TP2.1(TP) TP40.1(TP) TP41.1(TP) TP42.1(TP) TP44.1(TP) TP77.1(TP) TP85.1(TP) U46.2(GND) U59.4(GND) U59.9(EP) U71.3(GND) U73.4(GND) U73.7(EP) U133.1(GND) U133.2(GND) U133.3(GND) U133.7(GND) U134.3(AGND) U134.9(PGND1) U134.11(PGND2) U135.3(GND) U135.7(EP) ; also on sheet 1 2 12 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VBUS_TYPEC1: C326.1 C327.1 C654.1 C655.1 J24.A4(VBUS1) J24.A9(VBUS2) J24.B4(VBUS3) J24.B9(VBUS4) R3933.1 TP107.1(TP) U133.4(IN1) U133.5(IN2) U133.6(IN3) ; also on sheet 12 16
VCC_5V0: C197.1 C255.1 C3497.1 C3636.1 C3637.1 C3638.1 C3643.1 L24.2 R240.1 R3661.1 R3720.1 R3725.1 TP103.1(TP) U46.1(IN) U59.8(IN) U134.1(BIAS) U135.6(IN) ; also on sheet 1 12 16 18 37 42 43 45
VCC_5V0_PG: R3653.1 U134.5(PGOOD) ; also on sheet 16 23
VDD_CANUART: C207.1 R255.1 R5786.3 U46.5(OUT)
VDD_CANUART_N: R5786.1 ; also on sheet 49
VDD_CANUART_P: R5786.4 ; also on sheet 49
VDDSHV_CANUART: C3644.2 R3653.2 R3723.1 R3726.2 R5787.3 U135.1(OUT) ; also on sheet 16 17 23 24 45 46 52
VDDSHV_CANUART_N: R5787.1 ; also on sheet 49
VDDSHV_CANUART_P: R5787.4 ; also on sheet 49
VDDSHV_CANUART_PG: C3642.1 R3726.1 U135.5(PG)
CAN-FD_INH: R3028.2 ; also on sheet 45
EN_VSYS_5V0: R3028.1 R3727.2 R5740.2 U134.7(EN/SYNC)
LDO_3V3: C300.2 R195.1 U71.5(VCC) ; also on sheet 12
LM61460_BOOT: C3494.1 R5805.2 U134.14(CBOOT)
LM61460_FB: C3639.2 R3651.1 R3720.2 U134.4(FB)
LM61460_RT: R3652.1 U134.6(RT)
LM61460_SW: C3494.2 L24.1 U134.10(SW)
LM61460_VCC: C3627.2 U134.2(VCC)
PORT1_15W: R5767.1 U71.2(A) ; also on sheet 12
PORT2_15W: R381.1 U71.1(B) ; also on sheet 12
SOC_VDD_CANUART: R5786.2 TP52.1(TP) ; also on sheet 18 20
SOC_VDDSHV_CANUART: R5787.2 TP597.1(TP) ; also on sheet 18 20
USB_TYPEC1_EARTH: C648.1 J24.SH1 J24.SH2 J24.SH3 J24.SH4 R404.1
USBC_CONN1_CC1: D7.1(CATHODE) J24.A5(CC1) ; also on sheet 12
USBC_CONN1_CC2: D17.1(CATHODE) J24.B5(CC2) ; also on sheet 12
VMAIN: C310.1 C3625.1 C3628.1 C3629.1 C3630.1 C3631.1 R395.1 R5740.1 TP104.1(TP) U73.1(VOUT) U134.8(VIN1) U134.12(VIN2) ; also on sheet 45
VMAIN_EN: LD14.1(CATHODE) R382.1 U71.4(Y)
VMAIN_PD: C302.1 U73.6(VIN) ; also on sheet 12
VPP_1V8: R304.2 TP69.1(TP) ; also on sheet 18 20
VPP_EN: R319.1 ; also on sheet 47
VPP_SUPPLY: C247.2 C251.2 R304.1 U59.1(OUT)
N27107689: C308.1 U73.3(CT)
N27107697: R382.2 U73.5(EN/UVLO)
N27107782: R395.2 U73.2(QOD)
N27116765: R319.2 R320.1 U59.5(EN)
N27118410: R240.2 U46.3(EN)
N27118414: R255.2 R258.1 U46.4(FB)
N27765807: C3639.1 R3661.2
N27766023: R5805.1 U134.13(RBOOT)
N27780868: R3723.2 R3724.1 U135.2(FB)
N27781327: R3725.2 U135.4(EN)
N28157125: LD13.2(ANODE) R3933.2
N29184031: LD14.2(ANODE) R195.2

Not connected (* = marked no-connect by the designer): J24 A2(TX1+)* A3(TX1-)* A6(D+_1)* A7(D-_1)* A8(SBU1)* A10(RX2-)* A11(RX2+)* B2(TX2+)* B3(TX2-)* B6(D+_2)* B7(D-_2)* B8(SBU2)* B10(RX1-)* B11(RX1+)*; U59 2(NC1)* 3(NC2)* 6(NC3)* 7(NC4)*

## Notes on the sheets
sheet 13
- USB TYPE-C POWER CONNECTOR
- Silk: TYPE-C PWR
- LOAD SWITCH FOR VMAIN
- POWER INDICATION LED: VBUS_TYPEC1
- LD14 ON: VBUS_TYPEC1 or VBUS_TYPEC2
  does not meet power delivery requirements
- POWER ERROR
  INDICATION LED
- RED
sheet 14
- PERIPHERAL POWER SUPPLY - 1
- 5V, 6.0 AMPS SUPPLY
- LM61460-Q1   5V BUCK REGULATOR
  VinMin = 5V
  VinMax = 15V
  Vout = 5V
  Iout = 6A
- SILK SCREEN : VCC_5V0
- D-NOTE: Added pull down of 100k
  for fast discharge and low while HIGH-Z INH pin
- GND TEST POINTS
sheet 15
- PRE REGULATOR SUPPLY - LDOs
- 1.8V VPP (eFUSE), 0.5AMPS SUPPLY
- SILK SCREEN : VPP_1V8
- D-NOTE:U59 only needed  for eFUSE ROM programming. If no OTP operation, VPP can be left unconnected.
- VDD_CANUART(0.85V),0.5 AMPS SUPPLY
- Modify R258 to 274K for 0.75V operation
  MPN : ERJ-2RKF2743X
  Default is 0.85V
- VDDSHV_CANUART(1.8V),1 AMPS SUPPLY

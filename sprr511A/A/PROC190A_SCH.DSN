# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 30 to 34 of 57

## Sheets
30 29. SOC PERIPHERALS 1: size C; title: SOC PERIPHERALS 1
31 30. SOC PERIPHERALS 2: size C; title: SOC PERIPHERALS 2
32 31. SOC PERIPHERALS 3: size C; title: SOC PERIPHERALS 3
33 33. SOC ADC: size C; title: SoC ADC0 INTERFACE AND HEADER
34 34. AUDIO_REFERNCE_CLK: size C; title: AUDIO REFERENCE CLOCK

## Parts
sheet 16. SOC POWER SUPPLIES
U136  AM275x_EVM_SoC  [BGA361_31-49_630X630_1-5]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N)
sheet 29. SOC PERIPHERALS 1
R176  0E  [RES0402_0-5]
R177  0E  [RES0402_0-5]
R178  22E  [RES0402_0-5]
R179  22E  [RES0402_0-5]
R190  0E  [RES0402_0-5]
R191  0E  [RES0402_0-5]
R491  0E  [RES0402_0-5]
R492  0E  [RES0402_0-5]
R493  0E  [RES0402_0-5]
R494  0E  [RES0402_0-5]
R495  0E  [RES0402_0-5]
R498  0E  [RES0402_0-5]
R499  0E  [RES0402_0-5]
R500  0E  [RES0402_0-5]
R538  0E  [RES0201_0-5]
R5640  0E  [RES0402_0-5]
R5645  0E  [RES0402_0-5]
R5646  22E  [RES0402_0-5]
R5647  0E  [RES0402_0-5]
R5648  22E  [RES0402_0-5]
R5651  22E  [RES0402_0-5]
R5652  0E  [RES0402_0-5]
R5653  22E  [RES0402_0-5]
R5654  0E  [RES0402_0-5]
R5655  0E  [RES0402_0-5]
R5656  0E  [RES0402_0-5]
R5657  0E  [RES0402_0-5]
R5658  0E  [RES0402_0-5]
R5660  0E  [RES0402_0-5]
R5661  0E  [RES0402_0-5]
R5662  0E  [RES0402_0-5]
R5663  0E  [RES0402_0-5]
R5664  0E  [RES0402_0-5]
R5665  0E  [RES0402_0-5]
R5666  0E  [RES0402_0-5]
R5667  0E  [RES0402_0-5]
R5668  22E  [RES0402_0-5]
R5669  22E  [RES0402_0-5]
R5672  0E  [RES0402_0-5]
R5673  0E  [RES0402_0-5]
R5674  0E  [RES0402_0-5]
R5675  0E  [RES0402_0-5]
R5676  0E  [RES0402_0-5]
R5677  22E  [RES0402_0-5]
R5682  0E  [RES0402_0-5]
R5683  22E  [RES0402_0-5]
R5718  0E  [RES0402_0-5]
R5719  0E  [RES0402_0-5]
TP587  TP20_SMD  [TP20_SMD]
sheet 30. SOC PERIPHERALS 2
C182  100pF  [CAP0201_0-5]
C188  100pF  [CAP0201_0-5]
C3720  0.1uF  [CAP0201_0-5]
C3721  0.1uF  [CAP0201_0-5]
C3768  0.1uF  [CAP0201_0-5]
C3769  0.1uF  [CAP0201_0-5]
C3771  0.1uF  [CAP0201_0-5]
C3772  1uF  [CAP0201_0-5]
FL23  120E  [EMIFIL_BLM15A_0402_0-6]
R170  0E  [RES0603_0-75]
R210  62E_1%  [RES0402_0-5]
R216  22E  [RES0201_0-5]
R234  62E_1%  [RES0402_0-5]
R464  4.7K  [RES0201_0-5]
R465  4.7K  [RES0201_0-5]
R506  0E  [RES0402_0-5]
R598  4.7K  [RES0201_0-5]
R603  4.7K  [RES0201_0-5]
R684  4.7K  [RES0201_0-5]
R685  4.7K  [RES0201_0-5]
R5649  0E  [RES0402_0-5]
R5659  22E  [RES0201_0-5]
R5685  0E  [RES0603_0-75]
R5689  0E  [RES0402_0-5]
R5732  0E  [RES0201_0-5]
R5733  10K  [RES0201_0-5]
R5734  33.2E_1%  [RES0201_0-5]
R5788  0E  [RES0603_0-75]
R5789  10K  [RES0201_0-5]
R5790  10K  [RES0201_0-5]
R5791  0E  [RES0201_0-5]
R5792  0E  [RES0201_0-5]
R5793  0E  [RES0201_0-5]
R5808  10K  [RES0201_0-5]
R5843  10K  [RES0201_0-5]
U2353  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U3083  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]
U3084  LMK1C1102PWR  [TSSOP8_25-59_125X180_1-2]
sheet 31. SOC PERIPHERALS 3
R228  0E  [RES0201_0-5]
R239  0E  [RES0201_0-5]
R509  0E  [RES0201_0-5]
R518  0E  [RES0201_0-5]
R527  0E  [RES0201_0-5]
R528  0E  [RES0201_0-5]
R529  0E  [RES0201_0-5]
R530  0E  [RES0201_0-5]
R535  0E  [RES0201_0-5]
R537  0E  [RES0201_0-5]
R553  499E_1%  [RES0402_0-5]
sheet 33. SOC ADC
C3710  330pF  [CAP0402_0-75]
C3711  330pF  [CAP0402_0-75]
C3712  330pF  [CAP0402_0-75]
C3713  330pF  [CAP0402_0-75]
C3714  330pF  [CAP0402_0-75]
C3715  330pF  [CAP0402_0-75]
C3716  330pF  [CAP0402_0-75]
C3717  330pF  [CAP0402_0-75]
C3742  4.7uF  [CAP0402_0-75]
C3743  0.1uF  [CAP0201_0-5]
C3744  4.7uF  [CAP0402_0-75]
C3745  0.1uF  [CAP0201_0-5]
J31  HDR_6X2  [HDR_6X2_61301221121_P_S_T_8-6]
R5720  0E  [RES0402_0-5]
R5721  0E  [RES0402_0-5]
R5722  0E  [RES0402_0-5]
R5723  0E  [RES0402_0-5]
R5724  0E  [RES0402_0-5]
R5725  0E  [RES0402_0-5]
R5726  0E  [RES0402_0-5]
R5727  0E  [RES0402_0-5]
R5728  0E  [RES0402_0-5]
SW11  CAS-120TA  [SW3_CAS-120TA_215X100_SMD]
U2349  TPD4E02B04DQAR  [USON10_TPD4E05U_40X100_0-6]
U2350  TPD4E02B04DQAR  [USON10_TPD4E05U_40X100_0-6]
sheet 34. AUDIO_REFERNCE_CLK
C150  0.1uF  [CAP0201_0-5]
C151  0.1uF  [CAP0201_0-5]
C3703  0.1uF  [CAP0201_0-5]
C3704  0.1uF  [CAP0201_0-5]
R143  10K  [RES0201_0-5]
R5686  22E  [RES0201_0-5]
R5795  10K  [RES0201_0-5]
R5796  10K  [RES0201_0-5]
R5797  10K  [RES0201_0-5]
R5798  10K  [RES0201_0-5]
U29  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]
U2346  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]
U2347  TS5A3357QDCURQ1  [VSSOP8_19-68_85X95_0-9]

## Library data of the parts
U136 = AM275X_EVM_SOC_BGA361: IC AM275x EVM SoC BGA361; Chkd/date: PRADEEP/220524; Crtd /date: SHANKARI/210524; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Height: 1.42MM; Library Ref: AM275x_EVM_SoC_BGA361; Mfr_name: NA; Mistral Part No: 141324050006; Package: BGA361; Part_type: ICS\DIGITAL\FPGA; Project: AM275x_EVM; Remarks: FP NEED TO CHECK WITH MANUFACTURE AND CUSTOMER; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\AM275x_EVM_SoC.PDF
R176 R177 R190 R191 R491-R495 R498-R500 R506 R5640 R5645 R5647 R5652 R5654-R5658 R5660-R5667 R5672-R5676 R5682 R5689 R5718 R5719 R5728 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R178 R179 R5646 R5648 R5651 R5653 R5668 R5669 R5677 R5683 = RESISTOR: RES 22E 1/10W 5% 0402; Chkd/date: VASANTHA/060117; Crtd /date: MAZHAR/120505; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P22JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ220X; Mistral Part No: 110009030515-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: EPDA_CORE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R538 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_22E_1%_22E_1%; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP587 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
C182 C188 = CAP: CAP CERAMIC 100pF 16V 10% X7R 0201; Chkd/date: PRAVEEN/091222; Crtd /date: PRAVEEN/091222; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-6146-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R71C101KA01D; Mistral Part No: 120022120014-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: QUALCOMM_QRB5165_FLIGHT_KIT_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R71C101KA01D.PDF
C150 C151 C3704 C3720 C3721 C3743 C3745 C3768 C3769 C3771 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C3772 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
FL23 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 2A 0402; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM15PX121SZ1B; Mistral Part No: 130021120017-R; Package: 0402; Part_type: INDUCTOR; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM-SER.PDF
R170 R5685 R5788 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R210 R234 = RESISTOR: RES 62E 1/10W 1% 0402; Chkd/date: MANIRAJA/160318; Crtd /date: BAVISH/020611; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P62.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF62R0X; Mistral Part No: 110011060013-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM4515_EVM_LCD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R216 R5659 R5686 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
R464 R465 R598 R603 R684 R685 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5649 R5720-R5727 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5732 R5791-R5793 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R143 R5733 R5789 R5790 R5795-R5798 R5808 R5843 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5734 = RESISTOR: RES 33.2E 1/20W 1% 0201; Chkd/date: ALVY/150121; Crtd /date: ALVY/150121; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P122945CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-1GNF33R2C; Mistral Part No: 110021010009-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: AM223X_LP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 1%; Voltage: NA; Wattage: 1/20W; Weight: 0.15mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
U2353 = SN74AVC4T245RSV_UQFN16: IC 2-BIT BUS TRANSCEIVER WITH CONFIGURABLE VOLTAGE TRANSLATION AND 3 STATE O/P UQFN16; Chkd/date: MANIRAJA/040520; Crtd /date: BAVISH/190411; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24366-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_BUSDRIVERTRANSCEIVER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011040011-R; Package: UQFN16; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: HMC; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 41mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\SN74AVC4T245-SER.PDF
U29 U3083 = SN74AVC2T244DQMR_X2SON8: IC 2-BIT UNDIRECTIONAL VOLTAGE-LEVEL TRANSLATOR X2SON8; Chkd/date: VASANTHA/060516; Crtd /date: VASANTHA/030316; Customs_HS_Code: 15%; Distributor_name: DIGIKEY; Distributor_part_number: 296-29674-1-ND; Height: 0.40MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016030002-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Pb-Free: 85423100; Project: OCTASIC_3600; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\SN74AVC2T244.PDF
U3084 = LMK1C1102_TSSOP8: IC LVCMOS CLOCK BUFFER TSSOP8; Chkd/date: PRAVEEN/220922; Crtd /date: PRAVEEN/220922; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-LMK1C1102PWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141022090016-R; Package: TSSOP8; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: AM62A_SK_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 34.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\LMK1C1104.PDF
R228 R239 R509 R518 R527-R530 R535 R537 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R553 = RESISTOR: RES 499E 1/16W 1% 0402; Chkd/date: MANIRAJA/051020; Crtd /date: ALVY/051020; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-499LRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-07499RL; Mistral Part No: 110020080006-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM64XX_EVM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
C3710-C3717 = CAP: CAP CERAMIC 330pF 50V 5% C0G(NP0) AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT1555C1H331JA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT1555C1H331JA02D; Mistral Part No: 120019050019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT1555C1H331JA02.PDF
C3742 C3744 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R61A475ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61A475ME13D; Mistral Part No: 120021020032-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61A475ME13.PDF
J31 = HEADER_6X2: CON HDR 6X2 2.54MM PITCH ST TH; Chkd/date: PRADEEP/251124; Crtd /date: SHANKARI/251124; Custom_Duty: 0.24; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5297-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.54MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 61301221121; Mistral Part No: 150024110016-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: AM275X_EVM; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\61301221121PDF
SW11 = SWTACT_CAS-120TA: SWITCH TACT SPST SMD; Chkd/date: MAZHAR/221108; Crtd /date: USMAN/171008; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: CAS120JCT-ND; Height: 2.50MM; Mfr_name: COPAL ELECTRONICS; Mistral Part No: 130009030342; Package: SMD; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: SMART VIEW_IP CAMERA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\SWITCHES\CAS-XX.PDF
U2349 U2350 = TPD4E02B04DQAR_USON10: DIODE 4-CHANNEL ESD PROTECTION FOR USB-C USON10; Chkd/date: VASANTHA/220217; Crtd /date: MANIRAJA/210217; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: 296-43875-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130017020038-R; Package: USON10; Part_type: DIODE\TVS; Project: SD820_NANO_SOM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 28mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\TPD4E02B04DQAR.PDF
C3703 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
U2346 = TMUX1136_USON10: IC 5V LOW-LEAKAGE-CURRENT 2:1 2-CHANNEL PRECISION ANALOG SWITCH USON10; Chkd/date: MANIRAJA/291121; Crtd /date: ALVY/291121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-TMUX1136DQARCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_ANALOG-APPLICATION_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140121110003-R; Package: USON10; Part_type: ICS\ANALOG\SWITCH; Project: TI_AM263x_CC_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 4.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ANALOG\TMUX1136.PDF
U2347 = TS5A3357QDCURQ1_VSSOP8: IC 5E SP3T ANALOG SWITCH 3:1 MUX/DEMUX VSSOP8; Chkd/date: MANIRAJA/201217; Crtd /date: MANIRAJA/201217; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 296-32594-1-ND; Height: 0.90MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140117120004-R; Package: VSSOP8; Part_type: ICS\ANALOG\SWITCH; Project: FRED_DBW_CARRIER; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 9.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ANALOG\TS5A3357QDCURQ1.PDF

## Nets
DGND: C150.1 C151.1 C182.1 C188.1 C3703.2 C3704.1 C3710.2 C3711.2 C3712.2 C3713.2 C3714.2 C3715.2 C3716.2 C3717.2 C3720.1 C3721.1 C3744.2 C3745.1 C3768.1 C3769.1 C3771.1 C3772.1 J31.12 R143.2 R553.2 R5728.2 R5733.2 R5789.2 U29.5(GND) U2346.3(GND) U2347.4(GND) U2349.3(GND) U2349.8(GND) U2350.3(GND) U2350.8(GND) U2353.1(~{1OE}) U2353.7(1A2) U2353.9(2A2) U2353.10(GND1) U2353.11(GND2) U2353.12(2B2) U2353.14(1B2) U2353.16(~{2OE}) U3083.5(GND) U3084.4(GND) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VCC1V8_SYS: C151.2 C3703.1 C3704.2 C3721.2 C3769.2 R464.1 R465.1 R598.1 R603.1 R684.1 R685.1 R5795.1 R5796.1 R5797.1 R5798.1 R5808.2 U29.8(VCCB) U2346.8(VDD) U2347.8(V+) U2353.3(VCCA) U3083.1(VCCA) ; also on sheet 16 21 22 23 24 26 27 28 29 38 39 40 42 43 44 46 47 48 52 54 56
VCC3V3_XDS: C3720.2 U2353.2(VCCB) ; also on sheet 46 53 54 55
VCC_3V3_SYS: C150.2 C3768.2 FL23.2 R5843.1 U29.1(VCCA) U3083.8(VCCB) ; also on sheet 1 2 12 16 17 23 28 29 35 36 38 40 44 47 48 49 50 55 56
VCC_3V3_SYS_CLK_BUF: C3771.2 C3772.2 FL23.1 R5790.1 U3084.6(VDD)
VDDA_1V8: SW11.1 ; also on sheet 16 19 20
ADC0_AIN0: J31.1 R5720.2 U2349.1(IO1) U2349.10(NC4)
ADC0_AIN0_R: C3710.1 R5720.1 U136.F1(ADC0_AIN0)
ADC0_AIN1: J31.3 R5721.2 U2349.2(IO2) U2349.9(NC3)
ADC0_AIN1_R: C3711.1 R5721.1 U136.H1(ADC0_AIN1)
ADC0_AIN2: J31.5 R5722.2 U2349.4(IO3) U2349.7(NC2)
ADC0_AIN2_R: C3712.1 R5722.1 U136.K2(ADC0_AIN2)
ADC0_AIN3: J31.7 R5723.2 U2349.5(IO4) U2349.6(NC1)
ADC0_AIN3_R: C3713.1 R5723.1 U136.K1(ADC0_AIN3)
ADC0_AIN4: J31.9 R5724.2 U2350.1(IO1) U2350.10(NC4)
ADC0_AIN4_R: C3714.1 R5724.1 U136.F2(ADC0_AIN4)
ADC0_AIN5: J31.11 R5725.2 U2350.2(IO2) U2350.9(NC3)
ADC0_AIN5_R: C3715.1 R5725.1 U136.G2(ADC0_AIN5)
ADC0_AIN6: J31.4 R5726.2 U2350.4(IO3) U2350.7(NC2)
ADC0_AIN6_R: C3716.1 R5726.1 U136.J1(ADC0_AIN6)
ADC0_AIN7: J31.6 R5727.2 U2350.5(IO4) U2350.6(NC1)
ADC0_AIN7_R: C3717.1 R5727.1 U136.J2(ADC0_AIN7)
ADC0_EXT_TRIGGER: J31.8 U136.V2(GPIO1_49)
ADC0_REFN: C3742.2 C3743.1 R5728.1 U136.H2(ADC0_REFN)
ADC0_REFP: C3742.1 C3743.2 SW11.2(COM) U136.G1(ADC0_REFP)
ADC0_REFP_HDR: C3744.1 C3745.2 J31.2 SW11.3
AEC1_REFCLK_SEL: R5797.2 U2346.1(SEL1) ; also on sheet 47
AEC1_REFCLKIN: U2346.2(S1A) ; also on sheet 42
AEC1_REFCLKOUT: U2346.9(S1B) ; also on sheet 42
AEC2_REFCLK_SEL: R5798.2 U2346.5(SEL2) ; also on sheet 47
AEC2_REFCLKIN: U2346.4(S2A) ; also on sheet 43
AEC2_REFCLKOUT: U2346.7(S2B) ; also on sheet 43
AUDIO_EXT_REFCLK0: R538.2 U2346.10(D1)
AUDIO_EXT_REFCLK1: R506.2 U2346.6(D2)
AUDIO_EXT_REFCLK1__R: R506.1 U136.T1(SPI2_CS3)
AUDIO_EXT_REFCLK2: R5686.1 R5689.1
AUDIO_EXT_REFCLK2_R: R5689.2 U136.V3(GPIO1_72)
AUDIO_EXT_REFCLK2_S0: R5795.2 U2347.6(IN1) ; also on sheet 47
AUDIO_EXT_REFCLK2_S1: R5796.2 U2347.5(IN2) ; also on sheet 47
CDCE_CLKOUT_1: U2347.3(NO2) ; also on sheet 22
CPSW_RGMII1_BCLK: U29.3(A2) ; also on sheet 35
CPSW_RGMII1_BCLK_1V8: U29.6(B2) U2347.2(NO1)
CPSW_RGMII1_RD0: U136.W11(RGMII1_RD0) ; also on sheet 35
CPSW_RGMII1_RD1: U136.T11(RGMII1_RD1) ; also on sheet 35
CPSW_RGMII1_RD2: U136.T12(RGMII1_RD2) ; also on sheet 35
CPSW_RGMII1_RD3: U136.U12(RGMII1_RD3) ; also on sheet 35
CPSW_RGMII1_RX_DV: U136.V12(RGMII1_RX_CTL) ; also on sheet 35
CPSW_RGMII1_RXC: U136.W12(RGMII1_RXC) ; also on sheet 35
CPSW_RGMII1_TD0: R530.2 ; also on sheet 35
CPSW_RGMII1_TD1: R535.2 ; also on sheet 35
CPSW_RGMII1_TD2: R537.2 ; also on sheet 35
CPSW_RGMII1_TD3: R529.2 ; also on sheet 35
CPSW_RGMII1_TX_EN: U136.T13(RGMII1_TX_CTL) ; also on sheet 35
CPSW_RGMII1_TXC: R239.2 ; also on sheet 35
CPSW_RGMII2_BCLK: U29.2(A1) ; also on sheet 36
CPSW_RGMII2_BCLK_1V8: U29.7(B1) U2347.1(NO0)
CPSW_RGMII2_RD0: U136.U15(RGMII2_RD0) ; also on sheet 36
CPSW_RGMII2_RD1: U136.V15(RGMII2_RD1) ; also on sheet 36
CPSW_RGMII2_RD2: U136.W14(RGMII2_RD2) ; also on sheet 36
CPSW_RGMII2_RD3: U136.T15(RGMII2_RD3) ; also on sheet 36
CPSW_RGMII2_RX_DV: U136.V14(RGMII2_RX_CTL) ; also on sheet 36
CPSW_RGMII2_RXC: U136.W15(RGMII2_RXC) ; also on sheet 36
CPSW_RGMII2_TD0: R509.2 ; also on sheet 36
CPSW_RGMII2_TD1: R518.2 ; also on sheet 36
CPSW_RGMII2_TD2: R527.2 ; also on sheet 36
CPSW_RGMII2_TD3: R528.2 ; also on sheet 36
CPSW_RGMII2_TX_EN: U136.U16(RGMII2_TX_CTL) ; also on sheet 36
CPSW_RGMII2_TXC: R228.2 ; also on sheet 36
CPSW_RGMII2_TXC_R: R228.1 U136.W17(RGMII2_TXC)
CPSW_RGMII_TXC_R: R239.1 U136.V13(RGMII1_TXC)
ECAP0_IN_APWM_OUT: R5685.1 ; also on sheet 43
ECAP1_IN_APWM_OUT: U136.P2(SPI2_D0) ; also on sheet 42
ECAP2_IN_APWM_OUT: U136.R3(SPI2_D1) ; also on sheet 42
ECAP3_IN_APWM_OUT: U136.P4(GPIO1_48) ; also on sheet 43
EPWM0_A: U136.T2(SPI2_CS0) ; also on sheet 42
EPWM0_B: U136.R2(SPI2_CLK) ; also on sheet 42
EPWM1_A: U136.R1(SPI2_CS2) ; also on sheet 43
EXT_CLKOUT0: R170.1 ; also on sheet 22
EXT_CLKOUT0_R: R170.2 R5685.2 R5788.2 U136.P1(EXT_REFCLK1)
I2C0_SCL_1V8: C188.2 R234.2 R598.2 ; also on sheet 16 22 38 39 40 41 47 48
I2C0_SCL_1V8_RC: R234.1 U136.M3(I2C0_SCL)
I2C0_SDA_1V8: C182.2 R210.2 R603.2 ; also on sheet 16 22 38 39 40 41 47 48
I2C0_SDA_1V8_RC: R210.1 U136.N3(I2C0_SDA)
I2C3_SCL_1V8: R465.2 U136.N1(UART0_CTSn) ; also on sheet 42
I2C3_SDA_1V8: R464.2 U136.L3(UART0_RTSn) ; also on sheet 42
I2C5_SCL_1V8: R685.2 U136.L4(MCAN0_TX) ; also on sheet 43
I2C5_SDA_1V8: R684.2 U136.M4(MCAN0_RX) ; also on sheet 43
MCAN4_TX: R5649.1 ; also on sheet 42
MCAN4_TX_R: R5649.2 U136.R4(SPI2_CS1)
MCASP0_ACLKR: R5648.1 ; also on sheet 25 42
MCASP0_ACLKR_R: R5648.2 U136.R16(MCASP0_AXR12)
McASP0_ACLKX: R178.1 ; also on sheet 25 42
MCASP0_AFSR: R498.2 ; also on sheet 25 42
MCASP0_AFSR_R: R498.1 U136.T17(MCASP0_AXR13)
MCASP0_AFSX: R191.2 ; also on sheet 25 42
MCASP0_AFSX_R: R191.1 U136.M19(MCASP0_AFSX)
MCASP0_AXR0: R176.2 ; also on sheet 25 42
MCASP0_AXR0_R: R176.1 U136.N17(MCASP0_AXR0)
MCASP0_AXR1: R499.2 ; also on sheet 25 42
MCASP0_AXR1_R: R499.1 U136.M16(MCASP0_AXR1)
MCASP0_AXR2: R493.2 ; also on sheet 25 42
MCASP0_AXR2_R: R493.1 U136.N18(MCASP0_AXR2)
MCASP0_AXR3: R494.2 ; also on sheet 25 42
MCASP0_AXR3_R: R494.1 U136.M18(MCASP0_AXR3)
MCASP0_AXR4: R495.2 ; also on sheet 25 42
MCASP0_AXR4_R: R495.1 U136.N16(MCASP0_AXR4)
MCASP0_AXR5: R492.2 ; also on sheet 25 42
MCASP0_AXR5_R: R492.1 U136.P17(MCASP0_AXR5)
MCASP0_AXR6_R: R5718.1 U136.P18(MCASP0_AXR6)
MCASP0_AXR7: R177.2 ; also on sheet 25 42
MCASP0_AXR7_R: R177.1 U136.P19(MCASP0_AXR7)
MCASP0_AXR8_R: R5719.1 U136.P16(MCASP0_AXR8)
MCASP0_AXR9: R491.2 ; also on sheet 25 42
MCASP0_AXR9_R: R491.1 U136.R17(MCASP0_AXR9)
McASP1_ACLKR_R: R179.2 U136.T18(MCASP0_AXR14)
McASP1_ACLKX_R: R5646.2 U136.H19(MCASP1_ACLKX)
McASP1_AFSR_R: R5640.1 U136.T19(MCASP0_AXR15)
McASP1_AFSX_R: R5647.1 U136.J17(MCASP1_AFSX)
McASP1_AXR0_R: R500.1 U136.J18(MCASP1_AXR0)
McASP1_AXR1_R: R5645.1 U136.J19(MCASP1_AXR1)
McASP1_AXR2_R: R190.1 U136.J16(MCASP1_AXR2)
MCASP2_ACLKR: R5669.1 ; also on sheet 43
MCASP2_ACLKR_R: R5669.2 U136.G17(MCASP4_AXR1)
MCASP2_ACLKX: R5668.1 ; also on sheet 43
MCASP2_ACLKX_R: R5668.2 U136.L19(MCASP2_ACLKX)
MCASP2_AFSR: R5667.2 ; also on sheet 43
MCASP2_AFSR_R: R5667.1 U136.G16(MCASP4_AXR2)
MCASP2_AFSX: R5666.2 ; also on sheet 43
MCASP2_AFSX_R: R5666.1 U136.K19(MCASP2_AFSX)
MCASP2_AXR0: R5660.2 ; also on sheet 43
MCASP2_AXR0_R: R5660.1 U136.L17(MCASP2_AXR0)
MCASP2_AXR1: R5661.2 ; also on sheet 43
MCASP2_AXR1_R: R5661.1 U136.K16(MCASP2_AXR1)
MCASP2_AXR2: R5662.2 ; also on sheet 43
MCASP2_AXR2_R: R5662.1 U136.L18(MCASP2_AXR2)
MCASP2_AXR3: R5663.2 ; also on sheet 43
MCASP2_AXR3_R: R5663.1 U136.K18(MCASP2_AXR3)
MCASP2_AXR4: R5664.2 ; also on sheet 43
MCASP2_AXR4_R: R5664.1 U136.L16(MCASP2_AXR4)
MCASP2_AXR5: R5665.2 ; also on sheet 43
MCASP2_AXR5_R: R5665.1 U136.M17(MCASP2_AXR5)
MCASP3_ACLKR: R5683.1 ; also on sheet 43
MCASP3_ACLKX: R5677.1 ; also on sheet 43
MCASP3_AFSR: R5682.2 ; also on sheet 43
MCASP3_AFSX: R5676.2 ; also on sheet 43
MCASP3_AXR0: R5672.2 ; also on sheet 43
MCASP3_AXR1: R5673.2 ; also on sheet 43
MCASP3_AXR2: R5674.2 ; also on sheet 43
MCASP3_AXR3: R5675.2 ; also on sheet 43
MCASP4_ACLKR_FET: R5651.1 ; also on sheet 25 44
MCASP4_ACLKR_R: R5651.2 U136.R18(MCASP0_AXR10)
MCASP4_ACLKX_FET: R5653.1 ; also on sheet 44
MCASP4_ACLKX_R: R5653.2 R5683.2 U136.F18(MCASP4_ACLKX)
MCASP4_AFSR_FET: R5652.2 ; also on sheet 25 44
MCASP4_AFSR_R: R5652.1 U136.R19(MCASP0_AXR11)
MCASP4_AFSX_FET: R5655.2 ; also on sheet 44
MCASP4_AFSX_R: R5655.1 R5682.1 U136.F17(MCASP4_AFSX)
MCASP4_AXR0_FET: R5654.2 ; also on sheet 44
MCASP4_AXR0_R: R5654.1 U136.F19(MCASP4_AXR0)
MCASP4_AXR3_FET: R5658.2 ; also on sheet 44
MCASP4_AXR3_R: R5658.1 U136.U18(MLB0_MLBSIG)
MCASP4_AXR4_FET: R5656.2 ; also on sheet 44
MCASP4_AXR4_R: R5656.1 U136.U19(MLB0_MLBCLK)
MCASP4_AXR5_FET: R5657.2 ; also on sheet 44
MCASP4_AXR5_R: R5657.1 U136.V19(MLB0_MLBDAT)
MCU_INTn: U136.M2(I2C1_SDA) ; also on sheet 16
OBSCLK0: R5719.2 TP587.1(TP) ; also on sheet 25
PCM6240_McASP1_ACLKR: R179.1 ; also on sheet 40 41
PCM6240_McASP1_AFSR: R5640.2 ; also on sheet 40 41
PCM6240_McASP1_AXR0: R500.2 ; also on sheet 40 41
PCM6240_McASP1_AXR2: R190.2 ; also on sheet 41
RESETSTATz: R5843.2 U3083.6(B2) ; also on sheet 35 36 47
RESETSTATZ_1V8: U3083.3(A2) ; also on sheet 22 23 26 27 28 29 40 41 42 43 46 47
SD_MMC0_SDCD: U136.N2(I2C1_SCL) ; also on sheet 29
SOC_GPIO0_38: U136.K17(MCASP1_AXR3) ; also on sheet 47
SOC_UART0_RXD: R5734.2 U136.L2(UART0_RXD)
SOC_UART0_RXD_XDS: U2353.13(2B1) ; also on sheet 53
SOC_UART0_TXD: R5732.2 U2353.8(2A1)
SOC_UART0_TXD_XDS: U2353.15(1B1) ; also on sheet 53
SoC_USB0_DM: U136.W9(USB0_DM) ; also on sheet 37
SoC_USB0_DP: U136.V9(USB0_DP) ; also on sheet 37
SoC_USB0_DRVVBUS: U136.W2(USB0_DRVVBUS) ; also on sheet 23
SoC_USB0_RCALIB: R553.1 U136.V8(USB0_RCALIB)
SoC_USB0_VBUS: U136.U9(USB0_VBUS) ; also on sheet 37
SPI0_CLK: R216.1 ; also on sheet 42
SPI0_CLK_R: R216.2 U136.M1(SPI0_CLK)
SPI0_CS0: U136.J3(SPI0_CS0) ; also on sheet 42
SPI0_CS1: U136.J4(SPI0_CS1) ; also on sheet 42
SPI0_D0: U136.K3(SPI0_D0) ; also on sheet 42
SPI0_D1: U136.K4(SPI0_D1) ; also on sheet 42
SPI1_CLK: R5659.1 ; also on sheet 43
SPI1_CLK_R: R5659.2 U136.U2(SPI1_CLK)
SPI1_CS0: U136.U1(SPI1_CS0) ; also on sheet 43
SPI1_D0: U136.T3(SPI1_D0) ; also on sheet 43
SPI1_D1: U136.U3(SPI1_D1) ; also on sheet 43
SYNC1_OUT: R5788.1 U3083.2(A1)
SYNC1_OUT_3v3: R5793.1 U3084.1(CLKIN)
SYNC1_OUT_ETH1: R5791.2 ; also on sheet 35
SYNC1_OUT_ETH2: R5792.2 ; also on sheet 36
TAD5212_McASP1_ACLKX: R5646.1 ; also on sheet 38 39
TAD5212_McASP1_AFSX: R5647.2 ; also on sheet 38 39
TAD5212_McASP1_AXR1: R5645.2 ; also on sheet 38 39
UART2_RXD_FET: R5718.2 ; also on sheet 25 52
UART2_TXD_FET: U136.T4(SPI1_CS1) ; also on sheet 52
UART3_TXD_FET: U136.N4(GPIO1_47) ; also on sheet 52
N28080788: R143.1 U29.4(~{OE})
N28081065: R5686.2 U2347.7(COM)
N28084397: R530.1 U136.U13(RGMII1_TD0)
N28084399: R535.1 U136.W13(RGMII1_TD1)
N28084409: R537.1 U136.T14(RGMII1_TD2)
N28084411: R529.1 U136.U14(RGMII1_TD3)
N28084427: R509.1 U136.V16(RGMII2_TD0)
N28084429: R518.1 U136.W16(RGMII2_TD1)
N28084431: R527.1 U136.V17(RGMII2_TD2)
N28084433: R528.1 U136.W18(RGMII2_TD3)
N28118756: R5732.1 U136.L1(UART0_TXD)
N28895418: R5790.2 U3084.2(1G)
N28895646: R5791.1 U3084.3(Y0)
N28895649: R5792.1 U3084.8(Y1)
N28896188: R5789.1 U3083.4(~{OE})
N28896306: R5793.2 U3083.7(B1)
N29136309: R5808.1 U2353.5(2DIR)
N29136335: R5733.1 U2353.4(1DIR)
N29218455: R5734.1 U2353.6(1A1)
N29649563: R5672.1 U136.G18(MCASP3_AXR0)
N29649575: R5673.1 U136.H16(MCASP3_AXR1)
N29649587: R5674.1 U136.H18(MCASP3_AXR2)
N29649599: R5675.1 U136.H17(MCASP3_AXR3)
N29649611: R5676.1 U136.G19(MCASP3_AFSX)
N29649623: R5677.2 U136.E19(MCASP3_ACLKX)
N29649892: R538.1 U136.V1(AUDIO_EXT_REFCLK0)
N29650058: R178.2 U136.N19(MCASP0_ACLKX)

Not connected (* = marked no-connect by the designer): J31 10*; U3084 5(NC1)* 7(NC2)*

## Notes on the sheets
sheet 30
- SOC McASP
- GPIO0_38
- CAD-NOTE: 1. TRIPAD R5683 & R5653
            2. TRIPAD R5682 & R5655
sheet 31
- SOC - GENERAL
- GPIO1_29
- CAD-NOTE: TRIPAD R5685, R170 & R5788
sheet 32
- SOC CPSW3G ETHERNET INTERFACE
- Recommended 0E provision on
  RGMII TXC for signal integrity
- Recommended 0E provision on
  RGMII TXC for signal integrity
- SOC - USB
- 90E
- To Type- C connector
sheet 33
- SOC ADC
- ADC VREF DECAP
- ADC EXT HEADER
sheet 34
- AUDIO_EXT_REFCLK2_SELECTION
- AUDIO_EXT_
  REFCLK2_S0
- AUDIO_EXT_
  REFCLK2_S1
- AUDIO_EXT_
  REFCLK2
- 0
- 0
- -----
- 1
- 0
- CPSW_RGMII2_
  BCLK_1V8
- 0
- 1
- CPSW_RGMII1_
  BCLK_1V8
- (DEFAULT)
- 1
- 1
- CDCE_CLKOUT_1
- ETHERNET_BCLK LEVEL TRANSLATOR
- AUDIO EXPANSION REFCLK
- SELx
- D1
- D2
- 0
- S1B
- S2B
- 1
- S1A
- S2A
- (DEFAULT)

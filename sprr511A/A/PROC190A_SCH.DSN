# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 55 to 57 of 57

## Sheets
55 55. TEST AUTOMATION BUFFERS: size C; title: XDS110 TEST AUTOMATION BUFFERS
56 56. JTAG 20 PIN cTI CONNECTOR: size C; title: JTAG 20 PIN cTI CONNECTOR
57 57. MOUNTING HARDWARE: title: MOUNTING HARDWARE

## Parts
sheet 55. TEST AUTOMATION BUFFERS
C140  0.1uF  [CAP0201_0-5]
C147  0.1uF  [CAP0201_0-5]
C192  0.1uF  [CAP0201_0-5]
C235  0.1uF  [CAP0201_0-5]
C236  0.1uF  [CAP0201_0-5]
R118  4.7K  [RES0201_0-5]
R119  4.7K  [RES0201_0-5]
R219  0E  [RES0201_0-5]
R221  0E  [RES0201_0-5]
R224  0E  [RES0201_0-5]
R227  0E  [RES0201_0-5]
R233  0E  [RES0201_0-5]
R235  0E  [RES0201_0-5]
R277  1K  [RES0402_0-5]
R278  10K  [RES0201_0-5]
R280  10K  [RES0201_0-5]
R283  0E  [RES0201_0-5]
R285  10K  [RES0201_0-5]
R507  10K  [RES0201_0-5]
R510  10K  [RES0201_0-5]
R511  10K  [RES0201_0-5]
R512  10K  [RES0201_0-5]
R513  10K  [RES0201_0-5]
R515  10K  [RES0201_0-5]
R516  10K  [RES0201_0-5]
R517  10K  [RES0201_0-5]
R519  10K  [RES0201_0-5]
R524  10K  [RES0201_0-5]
R525  10K  [RES0201_0-5]
R526  10K  [RES0201_0-5]
TP58  TP20_SMD  [TP20_SMD]
TP61  TP20_SMD  [TP20_SMD]
U25  TCA9517DR  [SOIC8_1-8]
U40  SN74LVC07ADGVR  [TVSOP14_15-74_180X150_1-2]
U51  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]
sheet 56. JTAG 20 PIN cTI CONNECTOR
C169  0.1uF  [CAP0201_0-5]
C415  0.01uF  [CAP0201_0-5]
C416  0.01uF  [CAP0201_0-5]
C417  8.2pF  [CAP0201_0-5]
C455  0.1uF  [CAP0201_0-5]
C3724  0.1uF  [CAP0201_0-5]
C3725  0.1uF  [CAP0201_0-5]
C3726  0.1uF  [CAP0201_0-5]
C3727  0.1uF  [CAP0201_0-5]
C3728  0.1uF  [CAP0201_0-5]
C3729  0.1uF  [CAP0201_0-5]
C3730  0.1uF  [CAP0201_0-5]
J14  HDR_2X10  [HDR_2X10_FTR-110-51-D-06_S_S_8-7]
R211  10K  [RES0201_0-5]
R212  10K  [RES0201_0-5]
R214  1K  [RES0201_0-5]
R217  1K  [RES0201_0-5]
R220  10K  [RES0201_0-5]
R225  10K  [RES0201_0-5]
R476  33E  [RES0201_0-5]
R482  4.7K  [RES0201_0-5]
R483  33E  [RES0201_0-5]
R485  10K  [RES0201_0-5]
R487  100E_1%  [RES0402_0-5]
R489  10K  [RES0201_0-5]
R490  0E  [RES0201_0-5]
R531  10K  [RES0201_0-5]
R536  10K  [RES0201_0-5]
R566  22E  [RES0201_0-5]
R569  10K  [RES0201_0-5]
R5735  10K  [RES0201_0-5]
SW3  218-2LPST  [SW4_49-99_150X230_SMD_2-7]
U39  TXS0102DQER  [X2SON8_TXS0102_40X60_0-4]
U87  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]
U88  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]
U90  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]
U93  SN74LVC1G04DCKR  [SC70-5]
U110  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U2355  SN74LVC1G07DBVR  [SOT23-5]
sheet 57. MOUNTING HARDWARE
ACC2  SPC02SYAN  [NA]
ACC3  SPC02SYAN  [NA]
ACC9  970100327  [NA]
ACC10  PLAIN WASHER_M3  [NA]
ACC11  PLAIN WASHER_M3  [NA]
ACC12  PLAIN WASHER_M3  [NA]
ACC13  PLAIN WASHER_M3  [NA]
ACC14  970100327  [NA]
ACC15  970100327  [NA]
ACC16  970100327  [NA]
FID1  FID_40X80  [FID_40X80]
FID2  FID_40X80  [FID_40X80]
FID3  FID_40X80  [FID_40X80]
FID4  FID_40X80  [FID_40X80]
FID5  FID_40X80  [FID_40X80]
FID6  FID_40X80  [FID_40X80]
LBL1  THT-103-423-10  [NA]
LBL2  THT-103-423-10  [NA]
LBL3  AM6-COMPROCEVM  [NA]
LOGO1  Texas Intruments  [TI_Stacked_Overlay_Small]
LOGO2  For Evaluation only; not FCC approved for resale  [FCC_disclaimer]
LOGO3  WEEE Mark  [TI_Stacked_Overlay_Small]
LOGO4  CE Mark  [TI_Stacked_Overlay_Small]
MH1  PAN HEAD_M3 X 6  [NA]
MH2  PAN HEAD_M3 X 6  [NA]
MH3  PAN HEAD_M3 X 6  [NA]
MH4  PAN HEAD_M3 X 6  [NA]
PCB1  PROC190A

## Library data of the parts
C140 C147 C169 C192 C235 C236 C455 C3724-C3730 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
R118 R119 R482 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R219 R221 R224 R227 R233 R235 R283 R490 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R277 = RESISTOR: RES 1K 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.0KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ102X; Mistral Part No: 110009030400-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R211 R212 R220 R225 R278 R280 R285 R485 R489 R507 R510-R513 R515-R517 R519 R524-R526 R531 R536 R569 R5735 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP58 TP61 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U25 = TCA9517DGKR_VSSOP8: IC 2-CHANNEL BI-DIR LEVEL-SHIFTING I2C BUS REPEATER SOIC8; Chkd/date: MANIRAJA/171121; Crtd /date: ALVY/161121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-39221-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.75MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021110017-R; Package: SOIC8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: EXCITER MULTI-CH RX UNIT; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 540mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TCA9517.PDF
U40 = 74HC7014X_SOIC14: IC HEX BUFFER AND DRIVER WITH OPEN DRAIN OUTPUT TVSOP14; Chkd/date: ALVY/070422; Crtd /date: TAMILARASU/070422; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-8440-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141022040005-R; Package: TVSOP14; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: TI_AM62x_SKEVM_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 41.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74LVC07A.PDF
U39 U51 = TXS0102DQX_SON8: IC 2-BIT BI-DIR VOLTAGE-LEVEL TRANSLATOR FOR OPEN-DRAIN AND PUSH-PULL X2SON8; Chkd/date: MANIRAJA/010719; Crtd /date: CHAITHANYA230512; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-28368-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141012050010-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: GEN_3-8_DB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXS0102-SER.PDF
C415 C416 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
C417 = CAP: CAP CERAMIC 8.2pF 25V 0.5pF C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E8R2DA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E8R2DA02D; Mistral Part No: 120021120015-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 0.5pF%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E8R2DA02.PDF
J14 = HEADER_10X2_FTR-06: CON HDR 2X10 1.27MM PITCH ST SMD; Chkd/date: MANIRAJA/031218; Crtd /date: CHAITHANYA/050811; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: SAM8792-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.67MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: SAMTEC; Mfr_part_number: FTR-110-51-S-D-06; Mistral Part No: 150011090001-R; Package: SMD; Part_type: CONNECTOR\HEADERS; Project: GEMYC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\FTR-D-SER.PDF
R214 R217 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R476 R483 = RESISTOR: RES 33E 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-33NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0733RL; Mistral Part No: 110010070052-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R487 = RESISTOR: RES 100E 1/16W 1% 0402; Chkd/date: MANIRAJA/060318; Crtd /date: NAVEED/220714; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100LRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-07100RL; Mistral Part No: 110014070015-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: DLRU; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R566 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
SW3 = SW4_GDH02S04: SWITCH DIP SPST HALF PITCH 2POS SMD; Chkd/date: VASANTHA/080715; Crtd /date: VASANTHA/241221; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: CT2182LPST-ND; Height: 2.65MM; Mfr_name: CTS; Mistral Part No: 130014120040-R; Package: SMD; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: FREE SCALE POM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\SWITCHES\128-12LPST.PDF
U87 U88 = SN74LVC1G32_X2SON5: IC SINGLE 2-INPUT POSITIVE-OR GATE X2SON5; Chkd/date: MANIRAJA/141020; Crtd /date: ALVY/131020; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-SN74LVC1G32DPWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141020100011-R; Package: X2SON5; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G32XX.PDF
U90 = SN74AVC2T244DQMR_X2SON8: IC 2-BIT UNDIRECTIONAL VOLTAGE-LEVEL TRANSLATOR X2SON8; Chkd/date: VASANTHA/060516; Crtd /date: VASANTHA/030316; Customs_HS_Code: 15%; Distributor_name: DIGIKEY; Distributor_part_number: 296-29674-1-ND; Height: 0.40MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016030002-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Pb-Free: 85423100; Project: OCTASIC_3600; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\SN74AVC2T244.PDF
U93 = SN74LVC1G04DCKR_SC70-5: IC SINGLE INVERTER GATE SC70-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/150709; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-11600-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009070007-R; Part_type: ICS\DIGITAL\GATES; Project: BUG_BASE-II; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G04-1.PDF
U110 = SN74AVC4T245RSV_UQFN16: IC 2-BIT BUS TRANSCEIVER WITH CONFIGURABLE VOLTAGE TRANSLATION AND 3 STATE O/P UQFN16; Chkd/date: MANIRAJA/040520; Crtd /date: BAVISH/190411; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24366-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_BUSDRIVERTRANSCEIVER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011040011-R; Package: UQFN16; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: HMC; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 41mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\SN74AVC4T245-SER.PDF
U2355 = SN74LVC1G07DBVR_SOT23-5: IC SINGLE BUFFER/DRIVER SOT23-5; Chkd/date: MAZHAR/200208; Crtd /date: USMAN/200208; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-8485-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Junction to Board °C/W: 62; Junction to Case °C/W: 164; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009030405-R; Part_type: ICS\INTERFACE\LINE DRIVER; Project: MIB; RoHS: Sb/ Br FREE; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\SN74LVC1G07.PDF
ACC2 ACC3 = ACCESSORY: ACCESSORIE JUMPER SHORTING GOLD FLASH; Chkd/date: SUHAS\211010; Crtd /date: USMAN/301208; Distributor_name: DIGIKEY; Distributor_part_number: S9001-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: SULLINS CONNECTOR; Mistral Part No: 160009030153-R; Part_type: ACCESSORIES; Project: SMART VIEW_NVR; RoHS: RoHS; Temperature: -55°C+105°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MODULES\SPC02SYAN.PDF
ACC9 ACC14-ACC16 = ACCESSORY: ACCESSORIES HEX STANDOFF THREADED M3 STAINLESS STEEL (10.00MM) SILVER; Chkd/date: SHANKARI/120325; Crtd /date: SHANKARI/120325; Custom_Duty: 0.15; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 732-970100327-ND; Mfr_name: WURTH ELEKTRONIK; Mistral Part No: 160025020073-R; Part_type: ACCESSORIES; Project: AM275X_EVM; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\970100327.PDF
ACC10-ACC13 = WASHER_PLAIN: PLAIN WASHER FOR M3 NYLON; Chkd/date: MANIRAJA/071217; Crtd /date: MANIRAJA/071217; Distributor_name: DIGIKEY; Distributor_part_number: RPC1552-ND; Mfr_name: ESSENTRA; Mfr_part_number: MFW030A; Mistral Part No: 160017120032-R; Part_type: MECHANICAL\WASHERS; Project: TI_RF_DC CARD; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\WASHER-MFWXXX.PDF
FID1-FID6 = Fiducial
LBL1 LBL2 = ACCESSORY_THT-3-423-10: ACCESSORIE 1 WORKHORSE POLYSTER LABLE 0.25" X 1"; Chkd/date: MANIRAJA/270218; Crtd /date: ALVY/260218; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: BRADY; Mistral Part No: 160018020185; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB
LBL3 = ACCESSORY_THT-3-423-10: ACCESSORIE 1 WORKHORSE POLYSTER LABLE 0.25" X 1"; Chkd/date: MANIRAJA/270218; Crtd /date: ALVY/260218; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: BRADY; Mfr_part_number: THT-103-423-10; Mistral Part No: 160018020185; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB
LOGO1 LOGO3 LOGO4 = TI_Logo
LOGO2 = FCC_disclaimer
MH1-MH4 = SCREW_PAN: PHILLIPS PAN HEAD SCREW - M3 X 6 SS-316; Chkd/date: MANIRAJA/071217; Crtd /date: ALVY/061217; Distributor_name: DIGIKEY; Distributor_part_number: 335-1156-ND; Height: 6.00MM; Mfr_name: APM; Mfr_part_number: RM3X6MM 2701; Mistral Part No: 160017120033-R; Part_type: MECHANICAL\SCREWS; Project: TI_RF_DC CARD; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\RM3X6MM.PDF
PCB1 = PCB_0: PROC190A (AM275 EVM); Mistral Part No: FY22-23/00176000401

## Nets
DGND: C140.2 C147.2 C169.2 C192.2 C235.1 C236.1 C415.1 C416.1 C417.2 C455.1 C3724.1 C3725.1 C3726.1 C3727.1 C3728.1 C3729.1 C3730.1 J14.10 J14.12 J14.16 J14.20 R214.1 R217.1 R278.1 R489.1 R490.1 R531.1 R569.1 U25.4(GND) U39.4(GND) U40.7(GND) U51.4(GND) U87.3(GND) U88.3(GND) U90.3(A2) U90.5(GND) U90.6(B2) U93.3(GND) U110.10(GND1) U110.11(GND2) U2355.3(GND) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54
VCC1V8_SYS: C455.2 C3725.2 C3726.2 C3728.2 C3729.2 R220.1 R225.1 R536.2 U39.1(VCCA) U90.1(VCCA) U93.5(VCC) U110.3(VCCA) U2355.5(VCC) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 38 39 40 42 43 44 46 47 48 52 54
VCC1V8_TA: C236.2 R277.2 R285.1 R507.1 R511.1 R513.1 R516.1 R524.1 R526.1 U51.1(VCCA) ; also on sheet 25 46
VCC3V3_XDS: C147.1 C192.1 C235.2 R118.1 R119.1 R280.1 R510.1 R512.1 R515.1 R517.1 R519.1 R525.1 U25.8(VCCB) U40.14(VCC) U51.8(VCCB) ; also on sheet 31 46 53 54
VCC_3V3_SYS: C140.1 C169.1 C415.2 C416.2 C3724.2 C3727.2 C3730.2 J14.5 R211.1 R212.1 R482.1 R485.2 R5735.2 U25.1(VCCA) U39.8(VCCB) U87.5(VCC) U88.5(VCC) U90.8(VCCB) U110.2(VCCB) ; also on sheet 1 2 12 16 17 23 28 29 31 34 35 36 38 40 44 47 48 49 50
BUF_BOOTMODE_I2C0_SCL: R119.2 U25.7(SCLB) ; also on sheet 53
BUF_BOOTMODE_I2C0_SDA: R118.2 U25.6(SDAB) ; also on sheet 53
BUF_TEST_GPIO1: R519.2 U40.1(1A) ; also on sheet 53
BUF_TEST_GPIO2: R280.2 U51.7(B1) ; also on sheet 53
BUF_TEST_GPIO3: R515.2 U40.3(2A) ; also on sheet 53
BUF_TEST_GPIO4: R510.2 U40.5(3A) ; also on sheet 53
BUF_TEST_PORZn: R512.2 U40.9(4A) ; also on sheet 53
BUF_TEST_POWERDOWN: R525.2 U40.13(6A) ; also on sheet 53
BUF_TEST_WARMRESETn: R517.2 U40.11(5A) ; also on sheet 53
GPIO2_BUF_EN: R277.1 R278.2 U51.5(OE)
JTAG_cTI_RTCK: J14.9 R476.1
JTAG_cTI_TCK: J14.11 R485.1 R487.1 U87.1(B) U88.1(B)
JTAG_DIR: R569.2 U110.4(1DIR) U110.5(2DIR)
JTAG_EMU0: J14.13 R211.2 U39.7(B1)
JTAG_EMU1: J14.14 R212.2 U39.6(B2)
JTAG_EMU_RSTn: J14.15 R482.2 ; also on sheet 23
JTAG_TCK: R483.1 U110.14(1B2)
JTAG_TDI: J14.3 U110.12(2B2)
JTAG_TDIS: J14.4 R490.2
JTAG_TDO: J14.7 U90.7(B1)
JTAG_TMS: J14.1 U110.13(2B1)
JTAG_TRST#: J14.2 R489.2 U110.15(1B1)
SEL_XDS: U39.5(OE) U93.4(Y) ; also on sheet 54
SEL_XDS110_INV: J14.8 R531.2 R536.1 U90.4(~{OE}) U93.2(A) U110.1(~{1OE}) U110.16(~{2OE}) U2355.2(A) ; also on sheet 54
SEL_XDS110_INV_3V3: R5735.1 U87.2(A) U88.2(A) U2355.4(Y)
SoC_EMU0: R225.2 SW3.1 U39.2(A1) ; also on sheet 54
SoC_EMU1: R220.2 SW3.2 U39.3(A2) ; also on sheet 54
SoC_I2C0_SCL: U25.2(SCLA) ; also on sheet 12 35 36 47 48 49 50
SoC_I2C0_SDA: U25.3(SDAA) ; also on sheet 12 35 36 47 48 49 50
SoC_TCK: R566.1 ; also on sheet 54
SoC_TDI: U110.9(2A2) ; also on sheet 54
SoC_TDO: U90.2(A1) ; also on sheet 54
SoC_TMS: U110.8(2A1) ; also on sheet 54
SoC_TRST#: U110.6(1A1) ; also on sheet 54
TEST_GPIO1: R235.1 R526.2 ; also on sheet 24
TEST_GPIO2: R283.1 R285.2 ; also on sheet 47
TEST_GPIO3: R227.1 R516.2 ; also on sheet 46
TEST_GPIO4: R221.1 R511.2 ; also on sheet 46
TEST_PORZn: R219.1 R507.2 ; also on sheet 23
TEST_POWERDOWN: R233.1 R524.2 ; also on sheet 16
TEST_WARMRESETn: R224.1 R513.2 ; also on sheet 24
XDS_GPIO1: R235.2 U40.2(1Y)
XDS_GPIO2: R283.2 U51.2(A1)
XDS_GPIO3: R227.2 U40.4(2Y)
XDS_GPIO4: R221.2 U40.6(3Y)
XDS_PORZn: R219.2 U40.8(4Y)
XDS_POWERDOWN: R233.2 U40.12(6Y)
XDS_WARMRESETn: R224.2 U40.10(5Y)
N16994873: R483.2 U88.4(Y)
N16994875: R476.2 U87.4(Y)
N16995245: C417.1 R487.2
N19806973: R566.2 U110.7(1A2)
N24517110: R214.2 SW3.3
N24517112: R217.2 SW3.4
N27243596: TP61.1(TP) U51.3(A2)
N27243598: TP58.1(TP) U51.6(B2)

Not connected (* = marked no-connect by the designer): J14 17* 18* 19*; U25 5(EN)*; U93 1(NC)*; U2355 1(NC)*

## Notes on the sheets
sheet 55
- XDS110 TEST AUTOMATION BUFFERS
- This pulls provides a
  defined logic state to the
  Test Automation signals
  before XDS110 firmware is loaded
- Open Drain Buffer
  for Test Automation
  using XDS110
- Bidirectional Translator
  for Test Automation
  using XDS110
- SOC I2C BUS BUFFER
- TCA9517DR has internal
  Pullup resistors
sheet 56
- JTAG  BUFFERS
- cTI20 JTAG CONNECTOR
- JTAG_DIR = H: A -> B
  JTAG_DIR = L: B -> A
  OE = H: output = Hi-Z
- Silk: cTI
- Add an external ESD protection to provide system level ESD protection
- JTAG  CLOCK BUFFER
- NOTE: SW8.1 & SW8.2 - OFF
  (Default wait-in-reset disabled)
- It should be connected to PORz of the SoC TBD
sheet 57
- MOUNTING HARDWARE
- JUMPERS
- LOGOs
- FIDUCIALS
- ASSEMBLY NOTES
- 1. All MSL components should be baked as per JEDEC standard.
  2. PCB should be baked at 120 degree for 8 hours.
  3. Board assembly must comply with workmanship standards.
  IPC-A-610 Class 2, unless otherwise specified.
  4. These assemblies are ESD sensitive, ESD precautions
  shall be observed.
  5. These assemblies must be clean and free from flux and
  all contaminants. Use of no clean flux is not acceptable.
  6. Provide serial numbers to the assembled boards for identification.
  7. The assembled board are wrapped in ESD Covers(individual) and
  packed securely before shipment.
- Texas Intruments
- For Evaluation only; not FCC approved for resale
- WEEE Mark
- CE Mark
- BARE PCB
- SCREWS
- LABELS
- EVM Orderable No.
- Board Serial No.
- STANDOFFs
- Orderable Part Numbers
- Assembly Revision
- Variant
- Label Text
- 001
- AUDIO-AM275-EVM
- WASHER

# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 22 to 25 of 57

## Sheets
22 20. CDCE CLOCK GENERATION: size C; title: CDCE CLOCK GENERATION
23 21. SOC RESET - 1: size C; title: SOC  RESET - 1
24 22. SOC RESET - 2: size C; title: SOC RESET - 2
25 23. BOOT MODE SWITCHES: size C; title: BOOT MODE SWITCHES

## Parts
sheet 16. SOC POWER SUPPLIES
U136  AM275x_EVM_SoC  [BGA361_31-49_630X630_1-5]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N)
sheet 20. CDCE CLOCK GENERATION
C104  12pF  [CAP0201_0-5]
C105  12pF  [CAP0201_0-5]
C121  10uF  [CAP0402_0-75]
C265  1uF  [CAP0201_0-5]
C266  0.1uF  [CAP0201_0-5]
C284  0.1uF  [CAP0201_0-5]
C286  1uF  [CAP0201_0-5]
C290  10uF  [CAP0402_0-75]
C382  0.1uF  [CAP0201_0-5]
C383  0.1uF  [CAP0201_0-5]
C384  0.1uF  [CAP0201_0-5]
C385  10uF  [CAP0402_0-75]
C386  0.1uF  [CAP0201_0-5]
C387  0.1uF  [CAP0201_0-5]
FL10  120E  [EMIFIL_BLM15A_0402_0-6]
R73  0E  [RES0201_0-5]
R74  0E  [RES0201_0-5]
R75  4.7K  [RES0201_0-5]
R76  4.7K  [RES0201_0-5]
R83  4.7K  [RES0201_0-5]
R85  4.7K  [RES0201_0-5]
R89  0E  [RES0201_0-5]
R97  0E  [RES0603_0-75]
R329  10K  [RES0201_0-5]
R336  22E  [RES0201_0-5]
R337  0E  [RES0201_0-5]
R348  10K  [RES0201_0-5]
R349  22E  [RES0201_0-5]
R358  22E  [RES0201_0-5]
R359  22E  [RES0201_0-5]
TP32  TP30_SMD  [TP30_SMD]
TP33  TP30_SMD  [TP30_SMD]
TP36  TP30_SMD  [TP30_SMD]
TP37  TP30_SMD  [TP30_SMD]
TP38  TP30_SMD  [TP30_SMD]
TP39  TP30_SMD  [TP30_SMD]
U15  CDCE6214RGET  [WFQFN24_CDCE6214-Q1_160X160_0-9]
U62  25.000MHz  [VSON4_LMK6CE_80X100_SMD_1]
U65  LMK1C1103PWR  [TSSOP8_25-59_125X180_1-2]
Y1  24.576MHz  [XTAL4_ABMM_280X200_SMD_1-3]
sheet 21. SOC RESET - 1
C164  0.1uF  [CAP0201_0-5]
C165  0.1uF  [CAP0201_0-5]
C414  0.1uF  [CAP0201_0-5]
C421  0.1uF  [CAP0201_0-5]
C3775  0.1uF  [CAP0201_0-5]
C3779  0.1uF  [CAP0201_0-5]
C3780  0.1uF  [CAP0201_0-5]
C3781  0.1uF  [CAP0402_0-75]
J32  HDR_1X2  [HDR_1X2_61300211121_S_T_8-6]
R166  10K  [RES0201_0-5]
R205  0E  [RES0201_0-5]
R238  4.7K  [RES0201_0-5]
R242  10K  [RES0201_0-5]
R480  10K  [RES0201_0-5]
R5738  0E  [RES0402_0-5]
R5760  100K  [RES0402_0-5]
R5837  10K  [RES0201_0-5]
R5842  0E  [RES0201_0-5]
R5844  1.8K_1%  [RES0402_0-5]
R5845  10K  [RES0201_0-5]
TP49  TP20_SMD  [TP20_SMD]
TP54  TP20_SMD  [TP20_SMD]
TP100  TP20_SMD  [TP20_SMD]
TP592  TP20_SMD  [TP20_SMD]
TP594  TP20_SMD  [TP20_SMD]
U43  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]
U86  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]
U3077  TXS0104EPWR  [TSSOP14_25-59_205X180_1-2]
U3088  SN74LVC1G04DCKR  [SC70-5]
U3091  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]
sheet 22. SOC RESET - 2
C478  0.1uF  [CAP0201_0-5]
C489  0.1uF  [CAP0201_0-5]
C609  0.1uF  [CAP0201_0-5]
C622  0.1uF  [CAP0201_0-5]
C3740  0.1uF  [CAP0201_0-5]
C3741  0.1uF  [CAP0201_0-5]
D11  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D12  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D14  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D18  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
Q7  IRLML6401  [TO_SOT23-123]
Q12  IRLML6401  [TO_SOT23-123]
R268  10K  [RES0201_0-5]
R375  10K  [RES0201_0-5]
R546  4.7K  [RES0201_0-5]
R547  4.7K  [RES0201_0-5]
R550  10K  [RES0201_0-5]
R559  10K  [RES0201_0-5]
R615  10K  [RES0201_0-5]
R5756  10K  [RES0201_0-5]
SW5  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW6  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW8  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW10  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
TP50  TP20_SMD  [TP20_SMD]
TP55  TP20_SMD  [TP20_SMD]
U98  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]
U3070  SN74LVC1G17DCKR  [SC70-5]
sheet 23. BOOT MODE SWITCHES
R126  1K  [RES0201_0-5]
R127  1K  [RES0201_0-5]
R128  1K  [RES0201_0-5]
R129  1K  [RES0201_0-5]
R130  1K  [RES0201_0-5]
R131  1K  [RES0201_0-5]
R132  1K  [RES0201_0-5]
R133  1K  [RES0201_0-5]
R134  1K  [RES0201_0-5]
R135  1K  [RES0201_0-5]
R136  1K  [RES0201_0-5]
R137  1K  [RES0201_0-5]
R138  1K  [RES0201_0-5]
R139  1K  [RES0201_0-5]
R140  1K  [RES0201_0-5]
R141  1K  [RES0201_0-5]
R145  100K  [RES0201_0-5]
R146  100K  [RES0201_0-5]
R147  100K  [RES0201_0-5]
R148  100K  [RES0201_0-5]
R149  100K  [RES0201_0-5]
R150  100K  [RES0201_0-5]
R151  100K  [RES0201_0-5]
R152  100K  [RES0201_0-5]
R153  100K  [RES0201_0-5]
R154  100K  [RES0201_0-5]
R155  100K  [RES0201_0-5]
R156  100K  [RES0201_0-5]
R157  100K  [RES0201_0-5]
R158  100K  [RES0201_0-5]
R159  100K  [RES0201_0-5]
R160  100K  [RES0201_0-5]
RA2  1K  [RESA_EXB_0201-4_0-5]
RA5  1K  [RESA_EXB_0201-4_0-5]
RA6  1K  [RESA_EXB_0201-4_0-5]
RA7  1K  [RESA_EXB_0201-4_0-5]
SW1  416131160808  [SW16_416131160808_460X230_SMD_2-7]
SW2  416131160808  [SW16_416131160808_460X230_SMD_2-7]

## Library data of the parts
U136 = AM275X_EVM_SOC_BGA361: IC AM275x EVM SoC BGA361; Chkd/date: PRADEEP/220524; Crtd /date: SHANKARI/210524; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Height: 1.42MM; Library Ref: AM275x_EVM_SoC_BGA361; Mfr_name: NA; Mistral Part No: 141324050006; Package: BGA361; Part_type: ICS\DIGITAL\FPGA; Project: AM275x_EVM; Remarks: FP NEED TO CHECK WITH MANUFACTURE AND CUSTOMER; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\AM275x_EVM_SoC.PDF
C104 C105 = CAP: CAP CERAMIC 12pF 25V 5% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E120JA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E120JA02D; Mistral Part No: 120021120012-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E120JA02.PDF
C121 C290 C385 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C265 C286 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C164 C165 C266 C284 C414 C421 C478 C489 C609 C622 C3740 C3741 C3775 C3779 C3780 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C382-C384 C386 C387 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
FL10 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 2A 0402; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM15PX121SZ1B; Mistral Part No: 130021120017-R; Package: 0402; Part_type: INDUCTOR; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM-SER.PDF
R73 R74 R89 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_22E_1%_22E_1%; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R75 R76 R83 R85 R238 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R97 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R166 R242 R268 R329 R348 R375 R480 R550 R559 R615 R5756 R5837 R5845 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R336 R349 R358 R359 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
R205 R337 R5842 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP32 TP33 TP36-TP39 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U15 = CDCE6214_WFQFN24: IC CLOCK GENERATOR WITH 1-PLL 4-DIFFERENTIAL O/Ps 2-I/Ps AND EEPROM WFQFN24; Chkd/date: PRADEEP/290124; Crtd /date: TAMILARASU/290124; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-CDCE6214RGETCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141024010005-R; Package: WFQFN24; Part_type: ICS\DIGITAL\PERIPHERAL; Project: AM62D EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\PERIPHERAL\CDCE6214.PDF
U62 = OSC4_LMK6CE: OSC 25.00MHz LOW JITTER HIGH-PERFORMANCE BAW VSON4; Chkd/date: PRAVEEN/170423; Crtd /date: TAMILARASU/170423; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: NA; Distributor_part_number: NA; Height: 1.00MM; Mfr_name: TEXAS INSTRUMENTS; Mfr_part_number: LMK6CE02500DDLFT; Mistral Part No: 130023040014-R; Package: VSON4; Part_type: OSCILLATORS; Project: AM62P_SK; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\LMK61XXX-SER.PDF
U65 = LMK1C1103_TSSOP8: IC 3-CHANNEL LVCMOS CLOCK BUFFER TSSOP8; Chkd/date: MANIRAJA/080920; Crtd /date: ALVY/070920; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-LMK1C1103PWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141020090002-R; Package: TSSOP8; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 34.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\LMK1C110X.PDF
Y1 = CRY4_ABMM: CRY 24.576MHz 18pF SMD; Chkd/date: MANIRAJA/040918; Crtd /date: GEETHA/040506; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 535-9160-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.30MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: ABRACON; Mfr_part_number: ABMM-24.576MHZ-B2-T; Mistral Part No: 130009030042-R; Package: SMD; Part_type: CRYSTAL; Project: SCRIPTALKMAX; RoHS: RoHS; Temperature: -20°C+70°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 186.03mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\ABMM-SERIES.PDF
C3781 = CAP: CAP CERAMIC 0.1uF 16V 10% X7R AUTO 0402; Chkd/date: NAVEED/021014; Crtd /date: VASANTHA/300514; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-4759-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCM155R71C104KA55D; Mistral Part No: 120016070006-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DCMIST_FPGA_CARD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GCM-SER.PDF
J32 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: MANIRAJA/031018; Crtd /date: ALVY/031018; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5315-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.54MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 61300211121; Mistral Part No: 150018100003-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: ALPINE_EVM; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 120mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\6130XXX.PDF
R5738 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5760 = RESISTOR: RES 100K 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ104X; Mistral Part No: 110009030177-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5844 = RESISTOR: RES 1.8K 1/16W 1% 0402; Chkd/date: MANIRAJA/090817; Crtd /date: MANIRAJA/090817; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.80KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-071K8L; Mistral Part No: 110011010002-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: DM8147_PCI CARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP49 TP50 TP54 TP55 TP100 TP592 TP594 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U43 U86 = SN74LVC1G11DCKR_SC70-6: IC SINGLE 3-INPUT POSITIVE-AND GATE SON6; Chkd/date: MANIRAJA/270121; Crtd /date: ALVY/270121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30120-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021010013-R; Package: SON6; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G_NOV16.PDF
U3077 = TXS0104EPWR_TSSOP14: IC TRANSLATOR 4-BIT BIDIRECTIONAL VOLTAGE-LEVEL TSSOP14; Chkd/date: MANIRAJA/130617; Crtd /date: BAVISH/251110; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-20697-1-ND; Height: 1.20MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141010110011-R; Package: TSSOP14; Part_type: ICS\INTERFACE; Project: EM-FLS; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 57.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXS0104EPW.PDF
U3088 = SN74LVC1G04DCKR_SC70-5: IC SINGLE INVERTER GATE SC70-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/150709; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-11600-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009070007-R; Part_type: ICS\DIGITAL\GATES; Project: BUG_BASE-II; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G04-1.PDF
U3091 = SN74AVC2T244DQMR_X2SON8: IC 2-BIT UNDIRECTIONAL VOLTAGE-LEVEL TRANSLATOR X2SON8; Chkd/date: VASANTHA/060516; Crtd /date: VASANTHA/030316; Customs_HS_Code: 15%; Distributor_name: DIGIKEY; Distributor_part_number: 296-29674-1-ND; Height: 0.40MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016030002-R; Package: X2SON8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Pb-Free: 85423100; Project: OCTASIC_3600; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\SN74AVC2T244.PDF
D11 D12 D14 D18 = DIODE_SOD323: DIODE 1CH ESD PROTECTION X1SON2; Chkd/date: MANIRAJA/040420; Crtd /date: VASANTHA/181114; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30406-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130014110022-R; Package: X1SON2; Part_type: DIODE; Project: GALILEO_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD1E10B06-SER.PDF
Q7 Q12 = MOSFET_IRLML6401TR: TRANSISTOR MOSFET P-CHANNEL SOT23-3; Chkd/date: SHREESHAIL/020206; Crtd /date: MAZHAR/040505; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: IRLML6401PBFCT-ND; Height: 1.11MM; Mfr_name: IRF; Mfr_part_number: IRLML6401TRPBF; Mistral Part No: 130009031213-P; Package: SOT23-3; Part_type: TRANSISTOR\MOSFET; Project: G4_SVGA; RoHS: Pb-Free; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\IRLML6401.PDF
R546 R547 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
SW5 SW6 SW8 SW10 = 7914G-1-000E__7914G: SWITCH SPST-NO 4MM SQ SMD 7914G; Chkd/date: VASANTHA/271216; Crtd /date: BAVISH/051010; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 7914G-000ECT-ND; Height: 4.19MM; Library Ref: 7914G-1-000E _7914G; Mfr_name: BOURNS; Mistral Part No: 130015110004-R; Package: 7914G; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: AAAUC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\7914G-1-000E.PDF
U98 = SN74LVC3G17DCUR_VSSOP8: IC TRIPLE SCHMITT-TRIGGER BUFFER VSSOP8; Chkd/date: MANIRAJA/280917; Crtd /date: MANIRAJA/280917; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-18818-1-ND; Height: 0.90MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141017090019-R; Package: VSSOP8; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 9.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74LVC3G17.PDF
U3070 = SN74LVC1G17DCKR_SC70-5: IC SINGLE SCHMITT-TRIGGER BUFFER SC70-5; Chkd/date: MAZHAR/011210; Crtd /date: BAVISH/251110; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-11934-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141010110012-R; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: ITS-PWR_CARD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74LVC1G17DCK.PDF
R126-R141 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R145-R160 = RESISTOR: RES 100K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-07100KL; Mistral Part No: 110009030176-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
RA2 RA5-RA7 = RESARR_ISO4: RES ARRAY 1K 31mW 5% 0201-4; Chkd/date: NAVEED/110515; Crtd /date: VASANTHA/080515; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: Y6102CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: EXB-18V102JX; Mistral Part No: 110015050003-R; Package: 0201-4; Part_type: RESISTORS\ARRAY; Project: FREE SCALE NANO; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 31mW; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\EXB-18V.PDF
SW1 SW2 = SW16_CHS-08A: SWITCH SLIDE SPST ST SMD; Chkd/date: MANIRAJA/051020; Crtd /date: ALVY/011020; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-3857-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_SWITCH_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020100001-R; Package: SMD; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 281.7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\SWITCHES\4161311608XX.PDF

## Nets
DGND: C104.1 C105.2 C121.2 C164.2 C165.1 C265.2 C266.1 C284.1 C286.1 C290.2 C382.2 C383.2 C384.2 C385.2 C386.2 C387.2 C414.1 C421.1 C478.1 C489.1 C609.1 C622.1 C3740.1 C3741.1 C3775.1 C3779.1 C3780.1 C3781.2 D11.1 D12.1 D14.1 D18.1 J32.2 Q7.3(D) Q12.3(D) R76.2 R85.2 R145.2 R146.2 R147.2 R148.2 R149.2 R150.2 R151.2 R152.2 R153.2 R154.2 R155.2 R156.2 R157.2 R158.2 R159.2 R160.2 R238.2 R5760.1 SW5.1 SW5.4 SW6.1 SW6.4 SW8.1 SW8.4 SW10.1 SW10.4 U15.25(EP) U15.A1(GND) U15.A2(GND) U15.A3(GND) U15.A4(GND) U43.2(GND) U62.2(GND) U65.4(GND) U86.2(GND) U98.4(GND) U3070.3(GND) U3077.7(GND) U3088.3(GND) U3091.3(A2) U3091.5(GND) U3091.6(B2) Y1.2 Y1.4 ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VCC1V8_CLKBUF: C265.1 C266.2 C284.2 C286.2 FL10.1 R329.2 R348.2 U62.4(VDD) U65.6(VDD)
VCC1V8_SYS: C164.1 C414.2 C421.2 C478.2 C3775.2 C3779.2 R75.1 R83.1 R97.2 R166.1 R242.1 R268.1 R375.1 R480.1 R550.1 R559.1 R615.1 R5837.1 R5845.1 U43.5(VCC) U86.5(VCC) U98.8(VCC) U3077.1(VCCA) U3088.5(VCC) U3091.1(VCCA) ; also on sheet 16 21 26 27 28 29 31 34 38 39 40 42 43 44 46 47 48 52 54 56
VCC1V8_TA: R126.2 R127.2 R128.2 R129.2 R130.2 R131.2 R132.2 R133.2 R134.2 R135.2 R136.2 R137.2 R138.2 R139.2 R140.2 R141.2 ; also on sheet 46 55
VCC_3V3_SYS: C165.2 U3077.14(VCCB) ; also on sheet 1 2 12 16 17 28 29 31 34 35 36 38 40 44 47 48 49 50 55 56
VCC_5V0_PG: U86.3(B) ; also on sheet 14 16
VDDA1V8: C290.1 FL10.2 ; also on sheet 16
VDDSHV_CANUART: C3740.2 C3780.2 R5756.1 U3070.5(VCC) U3091.8(VCCB) ; also on sheet 14 15 16 17 45 46 52
BOOTMODE0: RA6.1 ; also on sheet 46
BOOTMODE1: RA2.1 ; also on sheet 46
BOOTMODE2: RA5.1 ; also on sheet 46
BOOTMODE3: RA2.2 ; also on sheet 46
BOOTMODE4: RA2.3 ; also on sheet 46
BOOTMODE5: RA6.4 ; also on sheet 46
BOOTMODE6: RA7.4 ; also on sheet 46
BOOTMODE7: RA5.3 ; also on sheet 46
BOOTMODE8: RA5.2 ; also on sheet 46
BOOTMODE9: RA2.4 ; also on sheet 46
BOOTMODE10: RA5.4 ; also on sheet 46
BOOTMODE11: RA7.1 ; also on sheet 46
BOOTMODE12: RA6.3 ; also on sheet 46
BOOTMODE13: RA6.2 ; also on sheet 46
BOOTMODE14: RA7.2 ; also on sheet 46
BOOTMODE15: RA7.3 ; also on sheet 46
CDCE_CLKOUT_1: R89.1 ; also on sheet 34
CLKOUT0: R336.2 R337.2 U65.1(CLKIN)
CLKOUT_OSC: R336.1 U62.3(OUT)
CPSW_ETH_INTn: U3077.12(B2) ; also on sheet 35
CPSW_ETH_INTn_1V8: R205.2 U3077.3(A2)
CPSW_RGMII1_ETH1_CLK: R359.2 ; also on sheet 35
CPSW_RGMII2_ETH2_CLK: R358.2 ; also on sheet 36
DEBOUNCE_GPIO_INT_MCU_SoC: C489.2 D11.2 Q7.2(S) R559.2 SW5.2 SW5.3 U98.3(2A)
DEBOUNCE_IORET_WAKE: C3741.2 D18.2 R5756.2 SW10.2 SW10.3 U3070.2(A)
DEBOUNCE_MCU_RESETz: C609.2 D12.2 Q12.2(S) R615.2 SW6.2 SW6.3 U98.1(1A)
DEBOUNCE_SOC_PORz: C622.2 D14.2 R375.2 SW8.2 SW8.3 U98.6(3A)
EXT_CLKOUT0: R337.1 ; also on sheet 31
GPIO_MCU_SoC: R546.1 R547.1 U98.5(2Y)
GPIO_MCU_SoC_INTn: R546.2 ; also on sheet 21
HW/SW_CTRL_SEL: R83.2 R85.1 U15.23(HW_SW_CTRL)
I2C0_SCL_1V8: U15.12(SCL/GPIO3) ; also on sheet 16 31 38 39 40 41 47 48
I2C0_SDA_1V8: U15.19(SDA/GPIO2) ; also on sheet 16 31 38 39 40 41 47 48
IORET_WAKE: U3070.4(Y) ; also on sheet 21
JTAG_EMU_RSTn: U86.6(C) ; also on sheet 56
MCASP0_ACLKR: RA7.7 ; also on sheet 30 42
McASP0_ACLKX: RA6.8 ; also on sheet 30 42
MCASP0_AFSR: RA7.6 ; also on sheet 30 42
MCASP0_AFSX: RA2.8 ; also on sheet 30 42
MCASP0_AXR0: RA5.8 ; also on sheet 30 42
MCASP0_AXR1: RA2.7 ; also on sheet 30 42
MCASP0_AXR2: RA2.6 ; also on sheet 30 42
MCASP0_AXR3: RA6.5 ; also on sheet 30 42
MCASP0_AXR4: RA7.5 ; also on sheet 30 42
MCASP0_AXR5: RA5.6 ; also on sheet 30 42
MCASP0_AXR7: RA2.5 ; also on sheet 30 42
MCASP0_AXR9: RA7.8 ; also on sheet 30 42
MCASP4_ACLKR_FET: RA6.6 ; also on sheet 30 44
MCASP4_AFSR_FET: RA6.7 ; also on sheet 30 44
MCU_GPIO0_1_INTn: R547.2 ; also on sheet 21 47
MCU_PORz: J32.1 R238.1 R242.2 TP49.1(TP) U43.4(Y) U136.E3(MCU_PORz) ; also on sheet 42 43
MCU_RESETz: R550.2 TP50.1(TP) U98.7(1Y) U136.D9(MCU_RESETz)
MCU_SAFETY_ERRORz_1V8: U3091.7(B1) ; also on sheet 16
MCU_SAFETY_ERRORz_1V8_BUF: R5842.1 TP54.1(TP) U136.F3(MCU_ERRORn)
MMC0_SEL_1V8: U3077.4(A3) ; also on sheet 21
MMC0_SEL_3V3: U3077.11(B3) ; also on sheet 2
OBSCLK0: RA5.5 ; also on sheet 30
PMIC_INTn: R205.1 U136.P3(EXTINTn) ; also on sheet 16
PMIC_POWERGOOD: U86.1(A) ; also on sheet 16
PRI/SEC_REF_SEL: R75.2 R76.1 U15.4(REFSEL)
RESET_STATZ: R5738.1 TP592.1(TP) U136.H4(RESETSTATz)
RESETSTATZ_1V8: R5738.2 R5760.2 TP100.1(TP) U15.8(PDN) U3088.2(A) ; also on sheet 26 27 28 29 31 40 41 42 43 46 47
RESETSTATZ_1V8_INV: R5844.1 R5845.2 U3088.4(Y) ; also on sheet 52
RESETSTATZ_1V8_INV_RC: C3781.1 R5844.2 U3091.4(~{OE})
SEC_REF_N: R74.1 U15.2(SECREF_N)
SEC_REF_P: R73.1 U15.1(SECREF_P)
SoC_CLKIN: R349.2 ; also on sheet 21
SoC_PORz: R480.2 U43.3(B) U86.4(Y)
SOC_PORz_PB: R268.2 TP55.1(TP) U43.1(A) U98.2(3Y)
SoC_USB0_DRVVBUS: U3077.5(A4) ; also on sheet 32
SoC_USB0_DRVVBUS_3V3: U3077.10(B4) ; also on sheet 12 37
SYS_BOOTMODE0: R153.1 SW2.1 ; also on sheet 46
SYS_BOOTMODE1: R154.1 SW2.2 ; also on sheet 46
SYS_BOOTMODE2: R155.1 SW2.3 ; also on sheet 46
SYS_BOOTMODE3: R156.1 SW2.4 ; also on sheet 46
SYS_BOOTMODE4: R157.1 SW2.5 ; also on sheet 46
SYS_BOOTMODE5: R158.1 SW2.6 ; also on sheet 46
SYS_BOOTMODE6: R159.1 SW2.7 ; also on sheet 46
SYS_BOOTMODE7: R160.1 SW2.8 ; also on sheet 46
SYS_BOOTMODE8: R145.1 SW1.1 ; also on sheet 46
SYS_BOOTMODE9: R146.1 SW1.2 ; also on sheet 46
SYS_BOOTMODE10: R147.1 SW1.3 ; also on sheet 46
SYS_BOOTMODE11: R148.1 SW1.4 ; also on sheet 46
SYS_BOOTMODE12: R149.1 SW1.5 ; also on sheet 46
SYS_BOOTMODE13: R150.1 SW1.6 ; also on sheet 46
SYS_BOOTMODE14: R151.1 SW1.7 ; also on sheet 46
SYS_BOOTMODE15: R152.1 SW1.8 ; also on sheet 46
TEST_GPIO1: Q7.1(G) ; also on sheet 55
TEST_PORZn: U43.6(C) ; also on sheet 55
TEST_WARMRESETn: Q12.1(G) ; also on sheet 55
UART2_RXD_FET: RA5.7 ; also on sheet 30 52
N27132714: R137.1 SW2.13
N27132716: R136.1 SW2.14
N27132718: R135.1 SW2.15
N27132720: R134.1 SW2.16
N27132816: R131.1 SW1.11
N27132818: R130.1 SW1.12
N27132820: R129.1 SW1.13
N27132822: R128.1 SW1.14
N27132824: R133.1 SW1.9
N27132826: R132.1 SW1.10
N27132828: R127.1 SW1.15
N27132836: R126.1 SW1.16
N27133243: R141.1 SW2.9
N27133247: R140.1 SW2.10
N27133249: R139.1 SW2.11
N27133251: R138.1 SW2.12
N27175817: C104.2 R74.2 Y1.1
N27175821: C105.1 R73.2 Y1.3
N27175987: C121.1 C382.1 C383.1 C384.1 C385.1 C386.1 C387.1 R97.1 U15.3(VDD_REF) U15.15(VDDO_34) U15.16(VDDO_12) U15.24(VDD_VCO)
N27176057: TP36.1(TP) U15.7(OUT0)
N27176072: R89.2 U15.22(OUT1_P)
N27176107: TP39.1(TP) U15.21(OUT1_N)
N27176638: TP37.1(TP) U15.11(GPIO4)
N27176640: TP38.1(TP) U15.20(GPIO1)
N27827107: TP594.1(TP) U136.A12(RSVD)
N27969798: R329.1 U62.1(OE/NC)
N27969912: R348.1 U65.2(1G)
N27970038: R349.1 U65.3(Y0)
N27970040: R358.1 U65.5(Y2)
N27970042: R359.1 U65.8(Y1)
N28238385: R166.2 U3077.8(OE)
N29181729: TP33.1(TP) U15.6(PRIREF_N)
N29181730: TP32.1(TP) U15.5(PRIREF_P)
N29598897: R5837.2 R5842.2 U3091.2(A1)

Not connected (* = marked no-connect by the designer): U15 9(OUT4_N)* 10(OUT4_P)* 13(OUT3_N)* 14(OUT3_P)* 17(OUT2_N)* 18(OUT2_P)*; U65 7(NC)*; U136 A3(RSVD)* B3(RSVD)* E2(RSVD)* E4(RSVD)* G3(RSVD)* W8(RSVD)*; U3070 1(NC)*; U3077 2(A1)* 6(NC1)* 9(NC2)* 13(B1)*; U3088 1(NC)*

## Notes on the sheets
sheet 22
- CDCE CLOCK GENERATION
- HW/SW_CTRL_SEL /
  PRI/SEC_REF_SEL
- PAGE_SELECT
- CLOCK_SOURCE
- LOW
- PAGE 0
- SEC_REF
- I2C ADDRESS: 0x68
- HIGH
- PAGE 1
- PRI_REF
- OSCILLATOR
- SOC & ETHERNET PHY CLOCK BUFFER
- DNI
- 25Mhz XTAL
- MCU_OSC0_XI
- EXT_REFCLK1
- DNI
- ETH1
- 1:3 CLK BUFF
- ETH2
- CAD-NOTE: TRIPAD R337 & R336
- 25Mhz Osc
sheet 23
- SOC  RESET - 1
- SOC - RESET
- Pull-down resistor on RESETSTATz is provided to keep the signal
  low until the processor is released from reset during the
  power-up seqence
- LEVEL TRANSLATOR
- MCU POWER ON RESET
- SOC POWER ON RESET
sheet 24
- SOC RESET - 2
- MCU WARM RESET
- RESET & INT DEBOUNCE CIRCUIT
- Silk: MCU WARM RST
- USER INTERRUPT
- LVCMOS inputs have slew rate requirement.
  Schmitt trigger is for the slow ramp pushbutton RC
  connected to the SoC warm reset inputs
  This is recommended when push button or RC is used.
- Silk: INT
- SOC PORZ
- IO RET WAKE
- Silk: PORz
- Silk: IO RET WAKE
sheet 25
- BOOT MODE SWITCHES
- D-Note: VCC1V8_TA supply is used for test automation.
  Connect SoC_DVDD1V8in the custom board design when buffers are not used
- BOOT MODES SUPPORTED
- SWITCH ON  =  LOGIC 1
  SWITCH OFF =  LOGIC 0
- 1. OSPI
- 2. MMC0 - SD CARD
- Silk: BMODE 0-7
- Silk: BMODE 8-15
- 3. UART
- 4. eMMC
- 5. ETHERNET
- 6. USB0 DFU
- 7. USB0 MS
- BOOTMODE PINS
- Signals from Bootmode buffer
- D-NOTE:
  1. 1K Resistor at the output of the buffer is
  recommended when the bootmode pins are used for
  alternate functions
  2. Replace 1K Resistor at the output of the buffer with
  resistor of value 0E when bootmode buffers are not used
- D-Note :
  Connect SYS_BOOTMODE signals when
  bootmode buffers are not used

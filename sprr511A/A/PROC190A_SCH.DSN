# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 41 to 44 of 57

## Sheets
41 42.  AUDIO MICROPHONE_LINE IN 2: size C; title: AUDIO - MICROPHONE/LINE IN 2
42 43. AUDIO EXPANSION 1: size C; title: AUDIO EXPANSION  CONNECTOR  #1
43 44. AUDIO EXPANSION 2: size C; title: AUDIO EXPANSION  CONNECTOR  #2
44 32. McASP4 MUX & MLB HEADER: size C; title: McASP4 FET SELECTION & MLB HEADER

## Parts
sheet 32. McASP4 MUX & MLB HEADER
C3698  0.1uF  [CAP0402_0-75]
C3701  0.1uF  [CAP0402_0-75]
C3702  0.1uF  [CAP0402_0-75]
J28  HDR_2X4  [HDR_2X4_90131-07_S_T_9-5]
J29  HDR_1X3  [HDR_1X3_87224-3_S_T_10-8]
R5681  10K  [RES0201_0-5]
R5684  10K_1%  [RES0402_0-5]
R5764  100K  [RES0402_0-5]
U2345  TXB0108PWR  [TSSOP20_25-59_260X180]
U3072  SN74CBTLV16292GR  [TSSOP56_19-68_560X240_1-2]
sheet 42.  AUDIO MICROPHONE_LINE IN 2
C2  0.1uF  [CAP0402_0-75]
C11  22uF  [CAP0402_1]
C12  22uF  [CAP0402_1]
C13  22uF  [CAP0402_1]
C14  22uF  [CAP0402_1]
C49  0.1uF  [CAP0402_0-75]
C52  2.2uF  [CAP0201_0-75]
C53  0.1uF  [CAP0201_0-5]
C54  2.2uF  [CAP0201_0-75]
C55  1uF  [CAP0201_0-5]
C60  0.1uF  [CAP0201_0-5]
C64  0.1uF  [CAP0201_0-5]
C65  1uF  [CAP0201_0-5]
C71  10uF  [CAP0402_0-75]
C74  0.1uF  [CAP0201_0-5]
C77  10uF  [CAP0402_0-75]
C78  0.1uF  [CAP0201_0-5]
C86  0.1uF  [CAP0201_0-5]
C90  1uF  [CAP0201_0-5]
C330  0.1uF  [CAP0402_0-75]
C335  22uF  [CAP0402_1]
C336  22uF  [CAP0402_1]
C337  22uF  [CAP0402_1]
C338  22uF  [CAP0402_1]
C340  0.1uF  [CAP0402_0-75]
C363  1uF  [CAP0805_1-5]
C368  10uF  [CAP0402_0-75]
J1  CON_AUDIOJACK6_STX-4235  [CON_AV6_STX-4235-3-3_S_R_T_26]  (sections A,B)
L2  2.2uH  [IND0806]
R3  4.3K  [RES0402_0-5]
R4  4.3K  [RES0402_0-5]
R5  4.3K  [RES0402_0-5]
R6  4.3K  [RES0402_0-5]
R46  0E  [RES0201_0-5]
R60  10K  [RES0201_0-5]
R61  10K  [RES0201_0-5]
R62  10K  [RES0201_0-5]
R63  10K  [RES0201_0-5]
R409  4.3K  [RES0402_0-5]
R410  4.3K  [RES0402_0-5]
R411  4.3K  [RES0402_0-5]
R412  4.3K  [RES0402_0-5]
R413  10K  [RES0402_0-5]
R414  0E  [RES0201_0-5]
R415  10K  [RES0402_0-5]
R416  10K  [RES0402_0-5]
R431  0E  [RES0402_0-5]
R432  0E  [RES0402_0-5]
R433  0E  [RES0402_0-5]
R435  0E  [RES0402_0-5]
TP25  TP30_SMD  [TP30_SMD]
TP26  TP30_SMD  [TP30_SMD]
TP27  TP30_SMD  [TP30_SMD]
TP31  TP30_SMD  [TP30_SMD]
U8  PCM6240QRTVRQ1  [QFN32_19-68_200X200_0-8_EP3-6]
U75  SN74LVC1G08DBVRE4  [SOT23-5]
sheet 43. AUDIO EXPANSION 1
C128  0.1uF  [CAP0201_0-5]
C129  0.1uF  [CAP0201_0-5]
C133  0.1uF  [CAP0201_0-5]
C137  0.1uF  [CAP0201_0-5]
C141  0.1uF  [CAP0201_0-5]
C161  0.1uF  [CAP0201_0-5]
C168  0.1uF  [CAP0201_0-5]
C172  0.1uF  [CAP0201_0-5]
C175  0.1uF  [CAP0201_0-5]
C176  0.1uF  [CAP0201_0-5]
J12  RECP_40X2  [CON_40X2_QSE-040-01_S_S_S]
R5650  33E  [RES0402_0-5]
R5775  0E  [RES0201_0-5]
sheet 44. AUDIO EXPANSION 2
C130  1uF  [CAP0201_0-5]
C134  1uF  [CAP0201_0-5]
C135  1uF  [CAP0201_0-5]
C138  1uF  [CAP0201_0-5]
C142  1uF  [CAP0201_0-5]
C160  1uF  [CAP0201_0-5]
C167  1uF  [CAP0201_0-5]
C170  1uF  [CAP0201_0-5]
C171  1uF  [CAP0201_0-5]
C174  1uF  [CAP0201_0-5]
J13  RECP_40X2  [CON_40X2_QSE-040-01_S_S_S]
R5670  33E  [RES0402_0-5]
R5776  0E  [RES0201_0-5]

## Library data of the parts
C3698 = CAP: CAP CERAMIC 0.1uF 16V 5% X7R 0402; Chkd/date: VASANTHA/211215; Crtd /date: VASANTHA/211215; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-6327-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R71C104JA88D; Mistral Part No: 120015120018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DLRL_NBSDR; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 16V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C3701 C3702 = CAP: CAP CERAMIC 0.1uF 16V 10% X7R 0402; Chkd/date: VASANTHA/090317; Crtd /date: MANIRAJA/090317; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 311-1338-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: CC0402KRX7R7BB104; Mistral Part No: 120009030060-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: CRADE_CONTROLLER CARD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\YACC-X7R.PDF
J28 = HEADER_4X2: CON HDR 2X4 2.54MM PITCH ST TH; Chkd/date: NAVEED/020615; Crtd /date: USMAN/031012; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM8140-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 9.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 90131-0764; Mistral Part No: 150012100007-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: NPOL_FEP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.494g; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\90131-0772.PDF
J29 = HEADER_3X1: CON HDR 1X3 2.54MM PITCH ST TH; Chkd/date: MANIRAJA/030717; Crtd /date: BAVISH/160211; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: A26545-ND; Height: 10.74MM; Mfr_name: TYCO ELECTRONICS; Mfr_part_number: 87224-3; Mistral Part No: 150011020004-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: OMAPL1_PEC20; RoHS: RoHS; Temperature: -65°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\87224.PDF
R60-R63 R5681 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5684 = RESISTOR: RES 10K 1/16W 1% 0402; Chkd/date: VASANTHA/201216; Crtd /date: GEETHA/290506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10.0KLRTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0710KL; Mistral Part No: 110015090015-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5764 = RESISTOR: RES 100K 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ104X; Mistral Part No: 110009030177-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
U2345 = TXB0108PWR_TSSOP20: IC 8-BIT BIDIRECTIONAL VOLTAGE-LEVEL TRANSLATOR TSSOP20; Chkd/date: SUHAS/131210; Crtd /date: USMAN/290409; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-21527-1-ND; Height: 1.20MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060007-R; Package: TSSOP20; Part_type: ICS\INTERFACE; Project: STORM2; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXB0108.PDF
U3072 = SN74CBTLV16292GR_TSSOP56: HIGH-SPEED FET MULTIPLEXER/DEMULTIPLEXER TSSOP56; Chkd/date: MANIRAJA/080817; Crtd /date: MAZHAR/250807; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-9105-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009030118-R; Package: TSSOP56; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: SMART VIEW_IP CAMERA; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 252.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74CBTLV1629.PDF
C2 C330 C340 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B3X7R1H104K050BB; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: C1005X7R1H104K050BE; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C11-C14 C335-C338 = CAP: CAP CERAMIC 22uF 10V 20% X5R 0402; Chkd/date: PRAVEEN/110822; Crtd /date: PRAVEEN/110822; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRM158R61A226ME15DCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM158R61A226ME15D; Mistral Part No: 120022080071-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: VOLTA_CHARGER V5; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C49 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C52 C54 = CAP: CAP CERAMIC 2.2uF 10V 20% X5R 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM035R61A225ME01; Mistral Part No: 120022060026-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM035R61A225ME01.PDF
C53 C60 C64 C74 C78 C86 C128 C129 C133 C137 C141 C161 C168 C172 C175 C176 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C55 C65 C90 C130 C134 C135 C138 C142 C160 C167 C170 C171 C174 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C71 C77 C368 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C363 = CAP: CAP CERAMIC 1uF 25V 5% X7R 0805; Chkd/date: PRADEEP/150424; Crtd /date: SHANKARI/150424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 478-KGM21AR71E105JUCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 08053C105JAT2A; Mistral Part No: 120024040007-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: AM62D_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_MLC.PDF
J1 = CON_AUDIOJACK6_STX-4235-3_3: CON AUDIO JACK DUAL 6POS 3.50MM FEMALE RT TH; Chkd/date: MANIRAJA/090818; Crtd /date: ALVY/080818; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: MOUSER; Distributor_part_number: 806-STX-4235-3/3-N; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 26.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Library Ref: CON_AUDIOJACK6_STX-4235-3/3; Mfr_name: KYCON; Mfr_part_number: STX-4235-3/3-N; Mistral Part No: 150018080005-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_FUSION2_SER_CAP; RoHS: RoHS; Temperature: -25°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\STX-4235-3-3-N.PDF
L2 = INDUCTOR: IND 2.2uH 20% 2.4A 0806; Chkd/date: PRADEEP/080124; Crtd /date: TAMILARASU/080124; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: F10231CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: LITTELFUSE INC; Mfr_part_number: LPWI201610H2R2T; Mistral Part No: 130024010015-R; Package: 0806; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: 0.2; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\LPWI201610H2R2T.PDF
R3-R6 R409-R412 = RESISTOR: RES 4.3K 1/16W 5% 0402; Chkd/date: VASANTHA/190614; Crtd /date: NAVEED/160614; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: RMCF0402JT4K30CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: STACKPOLE ELECTRONICS; Mfr_part_number: RMCF0402JT4K30; Mistral Part No: 110014060029-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS_POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RMCF-SER_JUL18.PDF
R46 R414 R5775 R5776 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R413 R415 R416 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R431-R433 R435 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP25-TP27 TP31 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U8 = PCM6240QRTVRQ1_WQFN32: IC AUTOMOTIVE 4-CHANNEL 768KHz AUDIO ADC WITH INTEGRATED MICROPHONE BIAS AND INPUT FAULT DIAGNOSTICS WQFN32; Chkd/date: PRADEEP/221123; Crtd /date: TAMILARASU/221123; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-PCM6240QRTVRQ1TR-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140223110001-R; Package: WQFN32; Part_type: ICS\ATOD; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ATOD_DTOA\PCM6240.PDF
U75 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: SN74LVC1G08QDBVRQ1; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
J12 J13 = CON40X2_SAMTEC: CON RECP 40X2 0.80MM PITCH SMD; Chkd/date: SUHAS/ 180311; Crtd /date: MUDDU/210510; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: SAM8124-ND; Height: 3.25MM; Mfr_name: SAMTEC; Mfr_part_number: QSE-040-01-L-D-A; Mistral Part No: 150010050008; Package: SMD; Part_type: CONNECTOR\RECEPTACLE; Project: L13xDC_IEB_PEB; Temperature: -55°C+125°C; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\QSE3-040.PDF
R5650 R5670 = RESISTOR: RES 33E 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P33JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ330X; Mistral Part No: 110009030699-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF

## Nets
DGND: C2.2 C11.1 C13.1 C49.2 C52.2 C53.1 C54.2 C55.2 C60.1 C64.2 C65.2 C71.2 C74.2 C77.2 C78.2 C86.2 C90.2 C128.2 C129.2 C130.2 C133.2 C134.2 C135.2 C137.2 C138.2 C141.2 C142.2 C160.2 C161.2 C167.2 C168.2 C170.2 C171.2 C172.2 C174.2 C175.2 C176.2 C330.2 C336.1 C338.1 C340.2 C363.2 C368.2 C3698.2 C3701.2 C3702.2 J1.1A J1.1B J12.7 J12.8 J12.15 J12.16 J12.22 J12.25 J12.26 J12.31 J12.35 J12.36 J12.45 J12.46 J12.49 J12.50 J12.57 J12.58 J12.65 J12.66 J12.75 J12.76 J12.81(GND1) J12.82(GND2) J12.83(GND3) J12.84(GND4) J12.85(GND5) J12.86(GND6) J12.87(GND7) J12.88(GND8) J13.7 J13.8 J13.15 J13.16 J13.22 J13.25 J13.26 J13.31 J13.35 J13.36 J13.45 J13.46 J13.49 J13.50 J13.57 J13.58 J13.65 J13.66 J13.75 J13.76 J13.81(GND1) J13.82(GND2) J13.83(GND3) J13.84(GND4) J13.85(GND5) J13.86(GND6) J13.87(GND7) J13.88(GND8) R61.2 R63.2 R415.1 R5681.2 U8.8(AVSS) U8.33(VSS) U75.3(GND) U2345.11(GND) U3072.8(GND1) U3072.19(GND2) U3072.38(GND4) U3072.49(GND3) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 45 46 47 48 49 50 51 52 53 54 55 56
VBAT_IN: C49.1 C55.1 U8.21(VBAT_IN) ; also on sheet 40
VCC1V8_SYS: C137.1 C138.1 C141.1 C142.1 C160.1 C161.1 C167.1 C168.1 C3701.1 J12.10 J12.12 J13.10 J13.12 J29.1 R5684.2 U2345.2(VCCA) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 38 39 40 46 47 48 52 54 56
VCC_1V8_IOVDD: C71.1 C74.1 C340.1 R60.1 R62.1 R413.2 R416.2 U8.27(IOVDD) U75.5(VCC) ; also on sheet 40
VCC_3V3_AVDD: C52.1 C53.2 C86.1 C90.1 L2.1 U8.1(AVDD) U8.3(BSTVDD) ; also on sheet 40
VCC_3V3_SYS: C3698.1 J29.3 R5764.2 U3072.17(VCC) ; also on sheet 1 2 12 16 17 23 28 29 31 34 35 36 38 40 47 48 49 50 55 56
VCC_5V0: C128.1 C129.1 C130.1 C133.1 C134.1 C135.1 C170.1 C171.1 C172.1 C174.1 C175.1 C176.1 J12.2 J12.4 J12.6 J13.2 J13.4 J13.6 ; also on sheet 1 12 14 15 16 18 37 45
AEC1_GPIO0_0: J12.42 ; also on sheet 21
AEC1_GPIO0_1: J12.44 ; also on sheet 27
AEC1_REFCLKIN: J12.33 ; also on sheet 34
AEC1_REFCLKOUT: J12.47 ; also on sheet 34
AEC2_GPIO0_0: J13.42 ; also on sheet 21
AEC2_GPIO0_1: J13.44 ; also on sheet 21
AEC2_REFCLKIN: J13.33 ; also on sheet 34
AEC2_REFCLKOUT: J13.47 ; also on sheet 34
ECAP0_IN_APWM_OUT: J13.11 ; also on sheet 31
ECAP1_IN_APWM_OUT: J12.9 ; also on sheet 31
ECAP2_IN_APWM_OUT: J12.11 ; also on sheet 31
ECAP3_IN_APWM_OUT: J13.9 ; also on sheet 31
EPWM0_A: J12.3 ; also on sheet 31
EPWM0_B: J12.5 ; also on sheet 31
EPWM1_A: J13.3 ; also on sheet 31
GPIO_PCM2_RST: R414.1 ; also on sheet 47
I2C0_SCL_1V8: U8.25(SCL_MOSI) ; also on sheet 16 22 31 38 39 40 47 48
I2C0_SDA_1V8: U8.26(SDA_SSZ) ; also on sheet 16 22 31 38 39 40 47 48
I2C3_SCL_1V8: J12.18 ; also on sheet 31
I2C3_SDA_1V8: J12.20 ; also on sheet 31
I2C5_SCL_1V8: J13.18 ; also on sheet 31
I2C5_SDA_1V8: J13.20 ; also on sheet 31
MCAN1_RX: R5670.1 ; also on sheet 21
MCAN1_RX_R: J13.53 R5670.2
MCAN1_TX: J13.51 ; also on sheet 21
MCAN4_RX: R5650.1 ; also on sheet 21
MCAN4_RX_R: J12.53 R5650.2
MCAN4_TX: J12.51 ; also on sheet 31
MCASP0_ACLKR: J12.43 ; also on sheet 25 30
McASP0_ACLKX: J12.37 ; also on sheet 25 30
MCASP0_AFSR: J12.41 ; also on sheet 25 30
MCASP0_AFSX: J12.39 ; also on sheet 25 30
MCASP0_AXR0: J12.27 ; also on sheet 25 30
MCASP0_AXR1: J12.29 ; also on sheet 25 30
MCASP0_AXR2: J12.28 ; also on sheet 25 30
MCASP0_AXR3: J12.30 ; also on sheet 25 30
MCASP0_AXR4: J12.32 ; also on sheet 25 30
MCASP0_AXR5: J12.34 ; also on sheet 25 30
MCASP0_AXR7: J12.38 ; also on sheet 25 30
MCASP0_AXR9: J12.40 ; also on sheet 25 30
MCASP2_ACLKR: J13.43 ; also on sheet 30
MCASP2_ACLKX: J13.37 ; also on sheet 30
MCASP2_AFSR: J13.41 ; also on sheet 30
MCASP2_AFSX: J13.39 ; also on sheet 30
MCASP2_AXR0: J13.27 ; also on sheet 30
MCASP2_AXR1: J13.29 ; also on sheet 30
MCASP2_AXR2: J13.28 ; also on sheet 30
MCASP2_AXR3: J13.30 ; also on sheet 30
MCASP2_AXR4: J13.32 ; also on sheet 30
MCASP2_AXR5: J13.34 ; also on sheet 30
MCASP3_ACLKR: J13.78 ; also on sheet 30
MCASP3_ACLKX: J13.77 ; also on sheet 30
MCASP3_AFSR: J13.80 ; also on sheet 30
MCASP3_AFSX: J13.79 ; also on sheet 30
MCASP3_AXR0: J13.67 ; also on sheet 30
MCASP3_AXR1: J13.69 ; also on sheet 30
MCASP3_AXR2: J13.71 ; also on sheet 30
MCASP3_AXR3: J13.73 ; also on sheet 30
MCASP4_ACLKR: J12.78 U3072.54(1B1)
MCASP4_ACLKR_FET: U3072.2(1A) ; also on sheet 25 30
MCASP4_ACLKR_HDR: J28.3 U2345.20(B1)
MCASP4_ACLKR_LT: U2345.1(A1) U3072.53(1B2)
MCASP4_ACLKX: J12.77 U3072.39(8B1)
MCASP4_ACLKX_FET: U3072.18(8A) ; also on sheet 30
MCASP4_ACLKX_HDR: J28.1 U2345.12(B8)
MCASP4_ACLKX_LT: U2345.9(A8) U3072.37(8B2)
MCASP4_AFSR: J12.80 U3072.52(2B1)
MCASP4_AFSR_FET: U3072.4(2A) ; also on sheet 25 30
MCASP4_AFSR_HDR: J28.7 U2345.18(B2)
MCASP4_AFSR_LT: U2345.3(A2) U3072.51(2B2)
MCASP4_AFSX: J12.79 U3072.41(7B1)
MCASP4_AFSX_FET: U3072.15(7A) ; also on sheet 30
MCASP4_AFSX_HDR: J28.5 U2345.13(B7)
MCASP4_AFSX_LT: U2345.8(A7) U3072.40(7B2)
MCASP4_AXR0: J12.67 U3072.50(3B1)
MCASP4_AXR0_FET: U3072.6(3A) ; also on sheet 30
MCASP4_AXR0_HDR: J28.8 U2345.17(B3)
MCASP4_AXR0_LT: U2345.4(A3) U3072.48(3B2)
MCASP4_AXR3: J12.69 U3072.43(6B1)
MCASP4_AXR3_FET: U3072.13(6A) ; also on sheet 30
MCASP4_AXR3_LT: U2345.7(A6) U3072.42(6B2)
MCASP4_AXR3_MLB0_SIG_HDR: J28.6 U2345.14(B6)
MCASP4_AXR4: J12.71 U3072.47(4B1)
MCASP4_AXR4_FET: U3072.9(4A) ; also on sheet 30
MCASP4_AXR4_LT: U2345.5(A4) U3072.46(4B2)
MCASP4_AXR4_MLB0_CLK_HDR: J28.4 U2345.16(B4)
MCASP4_AXR5: J12.73 U3072.45(5B1)
MCASP4_AXR5_FET: U3072.11(5A) ; also on sheet 30
MCASP4_AXR5_LT: U2345.6(A5) U3072.44(5B2)
MCASP4_AXR5_MLB0_DAT_HDR: J28.2 U2345.15(B5)
McASP4_FET_SEL: R5681.1 R5764.1 U3072.1(S) ; also on sheet 47
McASP_VSEL_HDR: C3702.1 J29.2 U2345.19(VCCB)
MCU_PORz: R5775.1 R5776.1 ; also on sheet 23
MIC2_BIAS: C2.1 C330.1 C363.1 R3.1 R4.1 R5.1 R6.1 R409.1 R410.1 R411.1 R412.1 U8.6(MICBIAS)
PCM1_GPIO1: R432.1 ; also on sheet 40
PCM2_ADDR_0: R62.2 R63.1 U8.24(ADDR0_SCLK)
PCM2_ADDR_1: R60.2 R61.1 U8.23(ADDR1_MISO)
PCM2_AREG: C64.1 C368.1 U8.2(AREG)
PCM2_BSTOUT: C54.1 C60.2 U8.5(BSTOUT)
PCM2_IN1N: C13.2 R5.2 U8.10(IN1M)
PCM2_IN1P: C14.2 R6.2 U8.9(IN1P)
PCM2_IN2N: C11.2 R3.2 U8.12(IN2M)
PCM2_IN2P: C12.2 R4.2 U8.11(IN2P)
PCM2_IN3N: C338.2 R412.2 U8.14(IN3M)
PCM2_IN3P: C337.2 R411.2 U8.13(IN3P)
PCM2_IN4N: C336.2 R410.2 U8.16(IN4M)
PCM2_IN4P: C335.2 R409.2 U8.15(IN4P)
PCM2_INT_1V8: R46.1 ; also on sheet 47
PCM2_McASP1_AXR0: R431.2 R433.1
PCM2_RESETn: R415.2 R416.1 U8.22(SHDNZ) U75.4(Y)
PCM2_VREF: C65.1 U8.7(VREF)
PCM6240_McASP1_ACLKR: U8.30(BCLK) ; also on sheet 30 40
PCM6240_McASP1_AFSR: U8.31(FSYNC) ; also on sheet 30 40
PCM6240_McASP1_AXR0: R431.1 ; also on sheet 30 40
PCM6240_McASP1_AXR2: R435.1 ; also on sheet 30
RESETSTATZ_1V8: J12.55 J13.55 U75.2(B) ; also on sheet 22 23 26 27 28 29 31 40 46 47
SPI0_CLK: J12.17 ; also on sheet 31
SPI0_CS0: J12.23 ; also on sheet 31
SPI0_CS1: J12.24 ; also on sheet 31
SPI0_D0: J12.19 ; also on sheet 31
SPI0_D1: J12.21 ; also on sheet 31
SPI1_CLK: J13.17 ; also on sheet 31
SPI1_CS0: J13.23 ; also on sheet 31
SPI1_CS1: J13.24 ; also on sheet 27
SPI1_D0: J13.19 ; also on sheet 31
SPI1_D1: J13.21 ; also on sheet 31
UART2_RXD: J12.62 ; also on sheet 52
UART2_TXD: J12.60 ; also on sheet 52
UART3_RXD: J13.62 ; also on sheet 52
UART3_TXD: J13.60 ; also on sheet 52
N27224404: R432.2 R433.2 R435.2 U8.29(SDOUT)
N27224468: C337.1 J1.5B
N27224561: L2.2 U8.4(BSTSW)
N27224667: C335.1 J1.2B
N27224751: TP27.1(TP) U8.18(GPIO3)
N27224753: TP31.1(TP) U8.20(GPIO2)
N27224897: C14.1 J1.5A
N27225024: C77.1 C78.1 U8.32(DREG)
N27225078: C12.1 J1.2A
N27225127: TP26.1(TP) U8.19(GPI1)
N27225129: TP25.1(TP) U8.17(GPI2)
N27225150: R46.2 U8.28(GPIO1)
N27226002: R413.1 R414.2 U75.1(A)
N28071414: R5684.1 U2345.10(OE)
N28496978: J12.1 R5775.2
N28497016: J13.1 R5776.2

Not connected (* = marked no-connect by the designer): J12 13* 14* 48* 52* 54* 56* 59* 61* 63* 64* 68* 70* 72* 74*; J13 5* 13* 14* 38* 40* 48* 52* 54* 56* 59* 61* 63* 64* 68* 70* 72* 74*; U3072 3(NC1)* 5(NC2)* 7(NC3)* 10(NC4)* 12(NC5)* 14(NC6)* 16(NC7)* 20(NC8)* 21(9A)* 22(NC9)* 23(10A)* 24(NC10)* 25(11A)* 26(NC11)* 27(12A)* 28(NC12)* 29(12B2)* 30(12B1)* 31(11B2)* 32(11B1)* 33(10B2)* 34(10B1)* 35(9B2)* 36(9B1)* 55(NC14)* 56(NC13)*

## Notes on the sheets
sheet 41
- AUDIO - MICROPHONE/LINE IN 2
- I2C ADDRESS: 0X49
- CAD Note: Resistors R3883, R3942, R3943
  shall share same pad
- PCM2 RESET
- ADC Supply & Decaps
- CAD Note: Place these decaps near the IOVDD supply pin
- I2C address selection
          device 2
- CAD Note: Place these decaps near the AVDD supply pin
sheet 42
- AUDIO EXPANSION  CONNECTOR  #1
- AUDIO EXPANSION DECAPS
sheet 43
- AUDIO EXPANSION CONNECTOR #2
- AUDIO EXPANSION DECAPS
sheet 44
- McASP4 FET SELECTION
- 1:2
  SWITCH
- FUNCTIONAL
  TABLE
- S
- A
- 0
- B1
- 1
- B2
- McASP HEADER 3.3/1.8 VOLTAGE SELECTION

# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 39 to 40 of 57

## Sheets
39 40. AUDIO LINEOUT - 2: size C; title: AUDIO - STEREO LINEOUT - 2
40 41. AUDIO MICROPHONE_LINE IN 1: size C; title: AUDIO - MICROPHONE/LINE IN 1

## Parts
sheet 40. AUDIO LINEOUT - 2
C20  1uF  [CAP0201_0-5]
C21  1uF  [CAP0201_0-5]
C26  47uF  [CAP0805_1-5]
C27  47uF  [CAP0805_1-5]
C30  0.1uF  [CAP0201_0-5]
C31  10uF  [CAP0402_0-75]
C35  1uF  [CAP0201_0-5]
C43  10uF  [CAP0402_0-75]
C46  0.1uF  [CAP0201_0-5]
C48  0.1uF  [CAP0201_0-5]
C51  0.1uF  [CAP0201_0-5]
C57  0.1uF  [CAP0201_0-5]
C62  0.1uF  [CAP0201_0-5]
C67  1uF  [CAP0201_0-5]
C73  0.1uF  [CAP0201_0-5]
C76  10uF  [CAP0402_0-75]
C341  1uF  [CAP0201_0-5]
C342  1uF  [CAP0201_0-5]
C345  47uF  [CAP0805_1-5]
C346  47uF  [CAP0805_1-5]
C349  10uF  [CAP0402_0-75]
C351  0.1uF  [CAP0201_0-5]
C353  1uF  [CAP0201_0-5]
C355  10uF  [CAP0402_0-75]
C357  0.1uF  [CAP0201_0-5]
C359  0.1uF  [CAP0201_0-5]
C361  0.1uF  [CAP0201_0-5]
C364  0.1uF  [CAP0201_0-5]
C366  0.1uF  [CAP0201_0-5]
C369  1uF  [CAP0201_0-5]
C371  0.1uF  [CAP0201_0-5]
C373  10uF  [CAP0402_0-75]
J4  CON_AUDIOJACK6_STX-4235  [CON_AV6_STX-4235-3-3_S_R_T_26]  (sections A,B)
R25  0E  [RES0201_0-5]
R27  10K  [RES0201_0-5]
R28  4.7K  [RES0201_0-5]
R30  10K  [RES0201_0-5]
R32  10K  [RES0201_0-5]
R35  22K  [RES0402_0-5]
R420  0E  [RES0201_0-5]
R430  10K  [RES0201_0-5]
R5643  0E  [RES0402_0-5]
R5644  0E  [RES0402_0-5]
TP11  TP30_SMD  [TP30_SMD]
TP14  TP30_SMD  [TP30_SMD]
TP19  TP30_SMD  [TP30_SMD]
TP20  TP30_SMD  [TP30_SMD]
TP23  TP30_SMD  [TP30_SMD]
TP110  TP30_SMD  [TP30_SMD]
TP111  TP30_SMD  [TP30_SMD]
TP114  TP30_SMD  [TP30_SMD]
U6  TAD5212IRGER  [QFN24_TAD5212IRGER_160X160_1]
U76  TAD5212IRGER  [QFN24_TAD5212IRGER_160X160_1]
sheet 41. AUDIO MICROPHONE_LINE IN 1
C3  0.1uF  [CAP0402_0-75]
C15  22uF  [CAP0402_1]
C16  22uF  [CAP0402_1]
C17  22uF  [CAP0402_1]
C18  22uF  [CAP0402_1]
C63  1uF  [CAP0201_0-5]
C68  0.1uF  [CAP0201_0-5]
C81  0.1uF  [CAP0201_0-5]
C82  10uF  [CAP0402_0-75]
C84  0.1uF  [CAP0201_0-5]
C85  10uF  [CAP0402_0-75]
C87  1uF  [CAP0201_0-5]
C89  0.1uF  [CAP0201_0-5]
C92  0.1uF  [CAP0201_0-5]
C95  1uF  [CAP0201_0-5]
C96  2.2uF  [CAP0201_0-75]
C97  0.1uF  [CAP0201_0-5]
C98  2.2uF  [CAP0201_0-75]
C100  0.1uF  [CAP0402_0-75]
C109  0.1uF  [CAP0402_0-75]
C329  0.1uF  [CAP0402_0-75]
C331  22uF  [CAP0402_1]
C332  22uF  [CAP0402_1]
C333  22uF  [CAP0402_1]
C334  22uF  [CAP0402_1]
C378  10uF  [CAP0402_0-75]
C379  1uF  [CAP0805_1-5]
FL2  120E  [EMIFIL_BLM18P_0603_0-8]
J2  CON_AUDIOJACK6_STX-4235  [CON_AV6_STX-4235-3-3_S_R_T_26]  (sections A,B)
J7  HDR_1X2  [HDR_1X2_90120-0122_S_T_5-6]
L3  2.2uH  [IND0806]
R7  4.3K  [RES0402_0-5]
R8  4.3K  [RES0402_0-5]
R9  4.3K  [RES0402_0-5]
R10  4.3K  [RES0402_0-5]
R20  10K  [RES0201_0-5]
R22  10K  [RES0201_0-5]
R23  10K  [RES0201_0-5]
R26  10K  [RES0201_0-5]
R34  0E  [RES0201_0-5]
R38  0E  [RES0402_0-5]
R67  0E  [RES0603_0-75]
R68  10K  [RES0402_0-5]
R78  10K  [RES0402_0-5]
R84  0E  [RES0201_0-5]
R90  10K  [RES0402_0-5]
R405  4.3K  [RES0402_0-5]
R406  4.3K  [RES0402_0-5]
R407  4.3K  [RES0402_0-5]
R408  4.3K  [RES0402_0-5]
TP5  TP30_SMD  [TP30_SMD]
TP6  TP30_SMD  [TP30_SMD]
TP8  TP30_SMD  [TP30_SMD]
TP9  TP30_SMD  [TP30_SMD]
U7  PCM6240QRTVRQ1  [QFN32_19-68_200X200_0-8_EP3-6]
U14  SN74LVC1G08DBVRE4  [SOT23-5]

## Library data of the parts
C20 C21 C35 C63 C67 C87 C95 C341 C342 C353 C369 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C26 C27 C345 C346 = CAP: CAP CERAMIC 47uF 10V 20% X5R 0805; Chkd/date: MANIRAJA/181018; Crtd /date: ALVY/181018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-9961-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM21BR61A476ME15L; Mistral Part No: 120014100011-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: RFID_MODULE-DESIGN; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 9.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM21BR61A476ME15L.PDF
C30 C46 C48 C51 C57 C62 C68 C73 C81 C84 C89 C92 C97 C351 C357 C359 C361 C364 C366 C371 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C31 C43 C76 C82 C85 C349 C355 C373 C378 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
J2 J4 = CON_AUDIOJACK6_STX-4235-3_3: CON AUDIO JACK DUAL 6POS 3.50MM FEMALE RT TH; Chkd/date: MANIRAJA/090818; Crtd /date: ALVY/080818; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: MOUSER; Distributor_part_number: 806-STX-4235-3/3-N; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 26.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Library Ref: CON_AUDIOJACK6_STX-4235-3/3; Mfr_name: KYCON; Mfr_part_number: STX-4235-3/3-N; Mistral Part No: 150018080005-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_FUSION2_SER_CAP; RoHS: RoHS; Temperature: -25°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\STX-4235-3-3-N.PDF
R25 R34 R84 R420 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R20 R22 R23 R26 R27 R30 R32 R430 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R28 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R35 = RESISTOR: RES 22K 1/16W 5% 0402; Chkd/date: MANIRAJA/310718; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-22KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0722KL; Mistral Part No: 110010120021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5643 R5644 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP5 TP6 TP8 TP9 TP11 TP14 TP19 TP20 TP23 TP110 TP111 TP114 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U6 U76 = TAD5212IRGER_QFN24: IC HIGH-PERFORMANCE STEREO AUDIO WITH 115db DYNAMIC RANGE DAC QFN24; Chkd/date: PRADEEP/271223; Crtd /date: TAMILARASU/271223; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141023120021-R; Package: QFN24; Part_type: ICS\DIGITAL\DSP; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DSP\TAD5212IRGER.PDF
C3 C109 C329 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B3X7R1H104K050BB; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: C1005X7R1H104K050BE; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C15-C18 C331-C334 = CAP: CAP CERAMIC 22uF 10V 20% X5R 0402; Chkd/date: PRAVEEN/110822; Crtd /date: PRAVEEN/110822; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRM158R61A226ME15DCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM158R61A226ME15D; Mistral Part No: 120022080071-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: VOLTA_CHARGER V5; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C96 C98 = CAP: CAP CERAMIC 2.2uF 10V 20% X5R 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM035R61A225ME01; Mistral Part No: 120022060026-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM035R61A225ME01.PDF
C100 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C379 = CAP: CAP CERAMIC 1uF 25V 5% X7R 0805; Chkd/date: PRADEEP/150424; Crtd /date: SHANKARI/150424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 478-KGM21AR71E105JUCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 08053C105JAT2A; Mistral Part No: 120024040007-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: AM62D_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_MLC.PDF
FL2 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 3A 0603; Chkd/date: MANIRAJA/251018; Crtd /date: ALVY/251018; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 490-13261-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.75MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM18KG121TH1D; Mistral Part No: 130018100051-R; Package: 0603; Part_type: INDUCTOR; Project: TI_J7ES_EVM_SOM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 4mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM18XX-H1D-SER.PDF
J7 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: NAVEED/210714; Crtd /date: USMAN/031012; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM8072-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 5.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 90120-0122; Mistral Part No: 150012100005-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: NPOL_FEP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 122mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\90120-XX.PDF
L3 = INDUCTOR: IND 2.2uH 20% 2.4A 0806; Chkd/date: PRADEEP/080124; Crtd /date: TAMILARASU/080124; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: F10231CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: LITTELFUSE INC; Mfr_part_number: LPWI201610H2R2T; Mistral Part No: 130024010015-R; Package: 0806; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: 0.2; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\LPWI201610H2R2T.PDF
R7-R10 R405-R408 = RESISTOR: RES 4.3K 1/16W 5% 0402; Chkd/date: VASANTHA/190614; Crtd /date: NAVEED/160614; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: RMCF0402JT4K30CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: STACKPOLE ELECTRONICS; Mfr_part_number: RMCF0402JT4K30; Mistral Part No: 110014060029-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS_POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RMCF-SER_JUL18.PDF
R38 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R67 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: PANASONIC-ECG; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R68 R78 R90 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U7 = PCM6240QRTVRQ1_WQFN32: IC AUTOMOTIVE 4-CHANNEL 768KHz AUDIO ADC WITH INTEGRATED MICROPHONE BIAS AND INPUT FAULT DIAGNOSTICS WQFN32; Chkd/date: PRADEEP/221123; Crtd /date: TAMILARASU/221123; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-PCM6240QRTVRQ1TR-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140223110001-R; Package: WQFN32; Part_type: ICS\ATOD; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ATOD_DTOA\PCM6240.PDF
U14 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: SN74LVC1G08QDBVRQ1; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF

## Nets
AVDD_3V3_DAC: C30.1 C31.1 C349.1 C351.1 R28.2 R35.2 U6.23(AVDD) U76.23(AVDD) ; also on sheet 38
DGND: C3.2 C15.1 C17.1 C20.1 C21.1 C30.2 C31.2 C35.2 C43.2 C46.2 C48.2 C51.2 C57.2 C62.2 C63.2 C67.2 C68.2 C73.2 C76.2 C81.2 C82.2 C84.2 C85.2 C87.2 C89.2 C92.1 C95.2 C96.2 C97.1 C98.2 C100.2 C109.2 C329.2 C332.1 C334.1 C341.1 C342.1 C349.2 C351.2 C353.2 C355.2 C357.2 C359.2 C361.2 C364.2 C366.2 C369.2 C371.2 C373.2 C378.2 C379.2 J2.1A J2.1B J4.1A J4.1B J7.2 R22.2 R26.2 R27.2 R30.2 R32.2 R68.1 R430.2 U6.25(EP_PAD) U6.A1(VSS) U6.A2(VSS) U6.A3(VSS) U6.A4(VSS) U7.8(AVSS) U7.33(VSS) U14.3(GND) U76.25(EP_PAD) U76.A1(VSS) U76.A2(VSS) U76.A3(VSS) U76.A4(VSS) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VBAT_IN: C95.1 C100.1 J7.1 U7.21(VBAT_IN) ; also on sheet 41
VCC1V8_SYS: C73.1 C76.1 C371.1 C373.1 R67.2 U6.6(IOVDD) U76.6(IOVDD) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 38 42 43 44 46 47 48 52 54 56
VCC_1V8_IOVDD: C84.1 C85.1 C109.1 R20.1 R23.1 R67.1 R78.2 R90.2 U7.27(IOVDD) U14.5(VCC) ; also on sheet 41
VCC_3V3_AVDD: C63.1 C68.1 C97.2 C98.1 FL2.2 L3.1 U7.1(AVDD) U7.3(BSTVDD) ; also on sheet 41
VCC_3V3_SYS: FL2.1 ; also on sheet 1 2 12 16 17 23 28 29 31 34 35 36 38 44 47 48 49 50 55 56
GPIO_PCM1_RST: R84.1 ; also on sheet 47
I2C0_SCL_1V8: U6.7(SCL) U7.25(SCL_MOSI) U76.7(SCL) ; also on sheet 16 22 31 38 41 47 48
I2C0_SDA_1V8: U6.8(SDA) U7.26(SDA_SSZ) U76.8(SDA) ; also on sheet 16 22 31 38 41 47 48
MIC1_BIAS: C3.1 C329.1 C379.1 R7.1 R8.1 R9.1 R10.1 R405.1 R406.1 R407.1 R408.1 U7.6(MICBIAS)
PCM1_ADDR_0: R20.2 R26.1 U7.24(ADDR0_SCLK)
PCM1_ADDR_1: R22.1 R23.2 U7.23(ADDR1_MISO)
PCM1_AREG: C89.1 C378.1 U7.2(AREG)
PCM1_BSTOUT: C92.2 C96.1 U7.5(BSTOUT)
PCM1_DREG: C81.1 C82.1 U7.32(DREG)
PCM1_GPIO1: R34.2 U7.28(GPIO1) ; also on sheet 41
PCM1_IN1N: C17.2 R9.2 U7.10(IN1M)
PCM1_IN1P: C18.2 R10.2 U7.9(IN1P)
PCM1_IN2N: C15.2 R7.2 U7.12(IN2M)
PCM1_IN2P: C16.2 R8.2 U7.11(IN2P)
PCM1_IN3N: C334.2 R408.2 U7.14(IN3M)
PCM1_IN3P: C333.2 R407.2 U7.13(IN3P)
PCM1_IN4N: C332.2 R406.2 U7.16(IN4M)
PCM1_IN4P: C331.2 R405.2 U7.15(IN4P)
PCM1_INT_1V8: R34.1 ; also on sheet 47
PCM1_McASP1_AXR0: R38.2 U7.29(SDOUT)
PCM1_RESETn: R68.2 R78.1 U7.22(SHDNZ) U14.4(Y)
PCM1_VREF: C87.1 U7.7(VREF)
PCM6240_McASP1_ACLKR: U7.30(BCLK) ; also on sheet 30 41
PCM6240_McASP1_AFSR: U7.31(FSYNC) ; also on sheet 30 41
PCM6240_McASP1_AXR0: R38.1 ; also on sheet 30 41
RESETSTATZ_1V8: U14.2(B) ; also on sheet 22 23 26 27 28 29 31 41 42 43 46 47
TAD3_ADDR3: R30.1 R35.1 U6.13(ADDR)
TAD3_DREG_OUT: C43.1 C46.1 U6.1(DREG)
TAD3_GPI3: R32.1 U6.12(GPI1)
TAD3_MICBIAS: C67.1 U6.14(MICBIAS)
TAD3_VREF: C35.1 U6.24(VREF)
TAD4_ADDR4: R27.1 R28.1 U76.13(ADDR)
TAD4_DREG_OUT: C355.1 C357.1 U76.1(DREG)
TAD4_GPI4: R430.1 U76.12(GPI1)
TAD4_MICBIAS: C369.1 U76.14(MICBIAS)
TAD4_VREF: C353.1 U76.24(VREF)
TAD5212_3_DIN: R5643.2 U6.5(DIN)
TAD5212_4_DIN: R5644.2 U76.5(DIN)
TAD5212_McASP1_ACLKX: U6.2(BCLK) U76.2(BCLK) ; also on sheet 30 38
TAD5212_McASP1_AFSX: U6.3(FSYNC) U76.3(FSYNC) ; also on sheet 30 38
TAD5212_McASP1_AXR1: R5643.1 R5644.1 ; also on sheet 30 38
N24605604: C18.1 J2.5A
N24605606: C16.1 J2.2A
N24605709: R84.2 R90.1 U14.1(A)
N24605835: TP5.1(TP) U7.20(GPIO2)
N24605846: L3.2 U7.4(BSTSW)
N24605909: C333.1 J2.5B
N24606047: TP8.1(TP) U7.19(GPI1)
N24606049: TP9.1(TP) U7.17(GPI2)
N24606166: C331.1 J2.2B
N24851304: R420.1 U76.4(DOUT)
N24851306: R420.2 TP14.1(TP)
N24851312: C346.1 J4.5B
N24851314: C345.1 J4.2B
N24851316: C345.2 U76.21(OUT2P)
N24851320: C342.2 U76.19(OUT1M)
N24851322: C341.2 U76.22(OUT2M)
N24851338: C346.2 U76.20(OUT1P)
N24851340: TP111.1(TP) U76.11(GPO1)
N24851385: C366.1 U76.15(IN1P)
N24851391: C364.1 U76.16(IN1M)
N24851397: C361.1 U76.17(IN2P)
N24851403: C359.1 U76.18(IN2M)
N24851421: TP110.1(TP) U76.9(GPIO1)
N24851423: TP114.1(TP) U76.10(GPIO2)
N24851452: R25.1 U6.4(DOUT)
N24851454: R25.2 TP11.1(TP)
N24851456: C27.1 J4.5A
N24851458: C26.1 J4.2A
N24851460: C26.2 U6.21(OUT2P)
N24851462: C21.2 U6.19(OUT1M)
N24851464: C20.2 U6.22(OUT2M)
N24851486: C27.2 U6.20(OUT1P)
N24851488: TP20.1(TP) U6.11(GPO1)
N24851535: C62.1 U6.15(IN1P)
N24851541: C57.1 U6.16(IN1M)
N24851547: C51.1 U6.17(IN2P)
N24851553: C48.1 U6.18(IN2M)
N24851571: TP19.1(TP) U6.9(GPIO1)
N24851573: TP23.1(TP) U6.10(GPIO2)
N25521527: TP6.1(TP) U7.18(GPIO3)

## Notes on the sheets
sheet 39
- AUDIO - STEREO LINEOUT - 2
- DAC Supply & Decaps
- I2C ADDRESS: 0x52
- CAD Note: Place these decaps near the DVDD supply pin of DAC's
- Device Straps
- I2C ADDRESS: 0x53
sheet 40
- AUDIO - MICROPHONE/LINE IN 1
- I2C ADDRESS: 0X48
- ADC Supply & Decaps
- PCM1 RESET
- CAD Note: Place these decaps near the IOVDD supply pin
- I2C address selection
          device 1
- CAD Note: Place these decaps near the AVDD supply pin

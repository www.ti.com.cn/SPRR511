# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 18 to 21 of 57

## Sheets
18 16. SOC POWER SUPPLIES: size C; title: SOC POWER SUPPLIES, SUPPLY RAILS AND SOC GROUND VSS
19 17. SOC PWR SUPPLIES - DECAPS 1: size C; title: SOC POWER SUPPLIES - DECAPS 1
20 18. SOC PWR SUPPLIES - DECAPS 2: size C; title: SOC POWER SUPPLIES - DECAPS 2
21 19. SOC WKUP & OSC: size C; title: SOC WKUP & CLOCK

## Parts
sheet 16. SOC POWER SUPPLIES
C432  1uF  [CAP0201_0-5]
C434  1uF  [CAP0201_0-5]
C443  1uF  [CAP0201_0-5]
C446  1uF  [CAP0201_0-5]
C449  22pF  [CAP0201_0-5]
C454  1uF  [CAP0201_0-5]
C484  1uF  [CAP0201_0-5]
C509  1uF  [CAP0201_0-5]
R543  10K_1%  [RES0603_0-75]
R545  1.1K_1%  [RES0603_0-5]
U136  AM275x_EVM_SoC  [BGA361_31-49_630X630_1-5]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N)
sheet 17. SOC PWR SUPPLIES - DECAPS 1
C202  10uF  [CAP0402_0-75]
C429  1uF  [CAP0201_0-5]
C437  1uF  [CAP0201_0-5]
C440  1uF  [CAP0201_0-5]
C441  0.22uF  [CAP0201_0-5]
C445  0.22uF  [CAP0201_0-5]
C447  0.1uF  [CAP0201_0-5]
C448  0.22uF  [CAP0201_0-5]
C451  1uF  [CAP0201_0-5]
C453  1uF  [CAP0201_0-5]
C460  0.22uF  [CAP0201_0-5]
C461  1uF  [CAP0201_0-5]
C462  0.22uF  [CAP0201_0-5]
C465  0.1uF  [CAP0201_0-5]
C466  0.1uF  [CAP0201_0-5]
C468  0.22uF  [CAP0201_0-5]
C471  1uF  [CAP0201_0-5]
C477  0.22uF  [CAP0201_0-5]
C483  1uF  [CAP0201_0-5]
C490  0.1uF  [CAP0201_0-5]
C493  0.1uF  [CAP0201_0-5]
C494  0.22uF  [CAP0201_0-5]
C502  1uF  [CAP0201_0-5]
C505  0.1uF  [CAP0201_0-5]
C506  1uF  [CAP0201_0-5]
C657  0.22uF  [CAP0201_0-5]
C658  0.22uF  [CAP0201_0-5]
C659  0.22uF  [CAP0201_0-5]
C660  1uF  [CAP0201_0-5]
C662  1uF  [CAP0201_0-5]
C663  1uF  [CAP0201_0-5]
C3661  1uF  [CAP0201_0-5]
C3751  1uF  [CAP0201_0-5]
C3752  1uF  [CAP0201_0-5]
C3753  2.2uF  [CAP0603_1]
C3754  2.2uF  [CAP0603_1]
C3755  10uF  [CAP0603_1]
C3756  4.7uF  [CAP0603_1]
C3757  10uF  [CAP0603_1]
C3758  0.1uF  [CAP0201_0-5]
C3759  0.1uF  [CAP0201_0-5]
C3760  2.2uF  [CAP0603_1]
sheet 18. SOC PWR SUPPLIES - DECAPS 2
C201  10uF  [CAP0402_1]
C224  1uF  [CAP0201_0-5]
C463  1uF  [CAP0201_0-5]
C467  1uF  [CAP0201_0-5]
C485  1uF  [CAP0201_0-5]
C495  1uF  [CAP0201_0-5]
C497  4.7uF  [CAP0201_0-5]
C501  1uF  [CAP0201_0-5]
C508  1uF  [CAP0201_0-5]
C512  1uF  [CAP0201_0-5]
C517  1uF  [CAP0201_0-5]
C3645  1uF  [CAP0201_0-5]
C3647  1uF  [CAP0201_0-5]
C3649  1uF  [CAP0201_0-5]
C3652  1uF  [CAP0201_0-5]
C3653  1uF  [CAP0201_0-5]
C3655  1uF  [CAP0201_0-5]
C3656  1uF  [CAP0201_0-5]
C3767  0.1uF  [CAP0201_0-5]
FL6  120E  [EMIFIL_BLM15A_0402_0-6]
FL8  26E  [EMIFIL_BLM18K_0603]
FL9  120E  [EMIFIL_BLM15A_0402_0-6]
FL13  120E  [EMIFIL_BLM15A_0402_0-6]
FL19  120E  [EMIFIL_BLM15A_0402_0-6]
FL20  120E  [EMIFIL_BLM15A_0402_0-6]
FL21  120E  [EMIFIL_BLM15A_0402_0-6]
FL22  120E  [EMIFIL_BLM15A_0402_0-6]
R3731  0E  [RES0402_0-5]
sheet 19. SOC WKUP & OSC
C205  18pF  [CAP0402_0-75]
C209  18pF  [CAP0402_0-75]
C213  18pF  [CAP0402_0-75]
C216  18pF  [CAP0402_0-75]
C245  100pF  [CAP0201_0-5]
C248  100pF  [CAP0201_0-5]
C3657  12pF  [CAP0201_0-5]
C3658  12pF  [CAP0201_0-5]
C3773  0.1uF  [CAP0201_0-5]
C3774  0.1uF  [CAP0201_0-5]
R82  0E  [RES0402_0-5]
R249  0E  [RES0201_0-5]
R252  0E  [RES0201_0-5]
R253  0E  [RES0201_0-5]
R254  0E  [RES0201_0-5]
R256  62E_1%  [RES0402_0-5]
R259  4.7K  [RES0201_0-5]
R261  0E  [RES0201_0-5]
R284  62E_1%  [RES0402_0-5]
R301  4.7K  [RES0201_0-5]
R541  0E  [RES0402_0-5]
R548  0E  [RES0402_0-5]
R568  1M  [RES0402_0-5]
R3732  0E  [RES0201_0-5]
R3733  0E  [RES0201_0-5]
R5671  0E  [RES0402_0-5]
R5750  0E  [RES0402_0-5]
R5751  0E  [RES0402_0-5]
R5806  10K  [RES0201_0-5]
R5830  1K  [RES0201_0-5]
TP75  TP20_SMD  [TP20_SMD]
TP586  TP20_SMD  [TP20_SMD]
U3086  SN74LV1T125DCKR  [SC70-5_1-1]
U3087  SN74LVC1G32DPWR  [X2SON5_TLV7021_30X30_0-4]
Y3  25.000MHz  [XTAL4_XRCGB-FM_80X60_SMD_0-7]
Y4  32.768KHz  [XTAL_ECS-32_130X60_SMD_0-9]
Y8  24.576MHz  [XTAL4_ABM3B_210X130_SMD]

## Library data of the parts
C224 C429 C432 C434 C437 C440 C443 C446 C451 C453 C454 C461 C463 C467 C471 C483-C485 C495 C501 C502 C506 C508 C509 C512 C517 C660 C662 C663 C3645 C3647 C3649 C3652 C3653 C3655 C3656 C3661 C3751 C3752 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C449 = CAP: CAP CERAMIC 22pF 25V 1% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E220FA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E220FA02D; Mistral Part No: 120021120014-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 1%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E220FA02.PDF
R543 = RESISTOR: RES 10K 1/10W 1% 0603; Chkd/date: MANIRAJA/061218; Crtd /date: ALVY/061218; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-5136-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW060310K0FKEAC; Mistral Part No: 110014070036-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: RFSU_POC-CARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW_C-SER.PDF
R545 = RESISTOR: RES 1.1K 1/10W 1% 0603; Chkd/date: MAZHAR/101210; Crtd /date: BAVISH/101210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-1.10KHCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.50MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW06031K10FKEA; Mistral Part No: 110010120049-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: IEMS; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
U136 = AM275X_EVM_SOC_BGA361: IC AM275x EVM SoC BGA361; Chkd/date: PRADEEP/220524; Crtd /date: SHANKARI/210524; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Height: 1.42MM; Library Ref: AM275x_EVM_SoC_BGA361; Mfr_name: NA; Mistral Part No: 141324050006; Package: BGA361; Part_type: ICS\DIGITAL\FPGA; Project: AM275x_EVM; Remarks: FP NEED TO CHECK WITH MANUFACTURE AND CUSTOMER; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\AM275x_EVM_SoC.PDF
C202 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C441 C445 C448 C460 C462 C468 C477 C494 C657-C659 = CAP: CAP CERAMIC 0.22uF 6.3V 10% X6S AUTO 0201; Chkd/date: MANIRAJA/220219; Crtd /date: ALVY/220219; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12230-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C80J224KE01D; Mistral Part No: 120019020011-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_J7ES_EVM_SOM; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 10%; Voltage: 6.3V; Wattage: NA; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GCM-SER.PDF
C447 C465 C466 C490 C493 C505 C3758 C3759 C3767 = CAP: CAP CERAMIC 0.1uF 6.3V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/011018; Crtd /date: MANIRAJA/011018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCM033C70J104KE02D; Mistral Part No: 120018100001-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_J7_SVB-DUT; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 6.3V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GCM-SER.PDF
C3753 C3754 C3760 = CAP: CAP CERAMIC 2.2uF 6.3V 10% X7R 0603; Chkd/date: PRADEEP/080324; Crtd /date: TAMILARASU/080324; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM188R70J225KE15; Mistral Part No: 120024030008-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: AM62D_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 6.3V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM188R70J225KE15.PDF
C3755 C3757 = CAP: CAP CERAMIC 10uF 16V 20% X6S AUTO 0603; Chkd/date: MANIRAJA/180920; Crtd /date: ALVY/170920; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12286-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT188C81C106ME13D; Mistral Part No: 120020090012-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: J7VCL_SOM_LEO_HERA_PMIC_BRD; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 16V; Wattage: NA; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT188C81C106ME13.PDF
C3756 = CAP: CAP CERAMIC 4.7uF 6.3V 20% X7S 0603; Chkd/date: PRADEEP/210824; Crtd /date: SHANKARI/210824; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRJ188C70J475ME11; Mistral Part No: 120024080027-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: AM275_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRJ188C70J475ME11.PDF
C201 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/150219; Crtd /date: ALVY/150219; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 1276-6830-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: SAMSUNG; Mfr_part_number: CL05A106MP8NUB8; Mistral Part No: 120019020008-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_60GHz-AOP; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\CL05A106MP8NUB8.PDF
C497 = CAP: CAP CERAMIC 4.7uF 6.3V 20% X5R 0201; Chkd/date: ALVY/020522; Crtd /date: TAMILARASU/020522; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: CAL-CHIP; Mfr_part_number: GMC02X5R475M6R3NT; Mistral Part No: 120022050001-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_AM62A_SK_EVM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\CALCHIP-GMC-SER.PDF
FL6 FL9 FL13 FL19-FL22 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 2A 0402; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM15PX121SZ1B; Mistral Part No: 130021120017-R; Package: 0402; Part_type: INDUCTOR; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM-SER.PDF
FL8 = EMIFILTER_IND: FERRITE CHIP 26E 6A 0603; Chkd/date: USMAN/020112; Crtd /date: CHAITHANYA/020112; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 490-5252-1-ND; Height: 0.75MM; Mfr_name: MURATA; Mfr_part_number: BLM18KG260TN1D; Mistral Part No: 130012010003-R; Package: 0603; Part_type: FILTER; Project: NA10NG; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM18K-SERIES.PDF
R82 R541 R548 R3731 R5671 R5750 R5751 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
C205 C209 C213 C216 = CAP: CAP CERAMIC 18pF 50V 5% HI-Q C0G(NP0) 0402; Chkd/date: VASANTHA/030315; Crtd /date: NAVEED/271014; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-3119-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GJM1555C1H180JB01D; Mistral Part No: 120014100019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DC_MIST_RDC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C245 C248 = CAP: CAP CERAMIC 100pF 16V 10% X7R 0201; Chkd/date: PRAVEEN/091222; Crtd /date: PRAVEEN/091222; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-6146-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R71C101KA01D; Mistral Part No: 120022120014-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: QUALCOMM_QRB5165_FLIGHT_KIT_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R71C101KA01D.PDF
C3657 C3658 = CAP: CAP CERAMIC 12pF 25V 5% C0G(NP0) AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT0335C1E120JA2D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT0335C1E120JA02D; Mistral Part No: 120021120012-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT0335C1E120JA02.PDF
C3773 C3774 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
R249 R252-R254 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R256 R284 = RESISTOR: RES 62E 1/10W 1% 0402; Chkd/date: MANIRAJA/160318; Crtd /date: BAVISH/020611; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P62.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF62R0X; Mistral Part No: 110011060013-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM4515_EVM_LCD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R259 R301 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R261 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R568 = RESISTOR: RES 1M 1/16W 5% 0402; Chkd/date: SHREESHAIL/061205; Crtd /date: SHREESHAIL/231105; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.0MJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-071ML; Mistral Part No: 110009030415-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: ADR; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R3732 R3733 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_22E_1%_22E_1%; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5806 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5830 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP75 TP586 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U3086 = SN74LV1T125DCKR_SC70-5: IC BUFFER GATE 3-STATE O/P CMOS LEVEL SHIFTER SC70-5; Chkd/date: VASANTHA/101214; Crtd /date: NAVEED/020914; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-37173-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141014090004-R; Package: SC70-5; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: DARE_DIO; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74LV1T125D.PDF
U3087 = SN74LVC1G32_X2SON5: IC SINGLE 2-INPUT POSITIVE-OR GATE X2SON5; Chkd/date: MANIRAJA/141020; Crtd /date: ALVY/131020; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-SN74LVC1G32DPWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141020100011-R; Package: X2SON5; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G32XX.PDF
Y3 = CRY4_13: CRY 25.000MHz 6pF SMD; Chkd/date: MANIRAJA/151020; Crtd /date: ALVY/151020; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 490-5578-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: XRCGB25M000F3M00R0; Mistral Part No: 130020100043-R; Package: SMD; Part_type: CRYSTAL; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -30°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 23mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\XRCGB.PDF
Y4 = CRY: CRY 32.768KHz 9pF SMD; Chkd/date: VASANTHA/090419; Crtd /date: ALVY/090419; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: XC2160CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: ECS INC; Mfr_part_number: ECS-.327-9-34QCS-TR; Mistral Part No: 130019040003-R; Package: SMD; Part_type: CRYSTAL; Project: J7ES_SOM_DUAL-LEO_PMIC; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 16mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\ECS-34Q.PDF
Y8 = CRY4_13: CRY 24.576MHz SMD; Chkd/date: SHREESHAIL/300506; Crtd /date: GEETHA/040506; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 300-8217-1-ND; Height: 1.10MM; Mfr_name: ABRACON; Mfr_part_number: ABM3B-24.576MHz-10-1-U-T; Mistral Part No: 130009030046-R; Package: SMD; Part_type: CRYSTAL; Project: SVDO_RMB_MMA; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\ABM3B.PDF

## Nets
DGND: C201.2 C202.2 C205.1 C209.1 C213.1 C216.1 C224.2 C245.2 C248.2 C429.2 C432.2 C434.2 C437.2 C440.2 C441.2 C443.2 C445.2 C446.2 C447.2 C448.2 C449.1 C451.2 C453.2 C454.2 C460.2 C461.2 C462.2 C463.2 C465.2 C466.2 C467.2 C468.2 C471.2 C477.2 C483.2 C484.2 C485.2 C490.2 C493.2 C494.2 C495.2 C497.2 C501.2 C502.2 C505.2 C506.2 C508.2 C509.2 C512.2 C517.2 C657.2 C658.2 C659.2 C660.2 C662.2 C663.2 C3645.2 C3647.2 C3649.2 C3652.2 C3653.2 C3655.2 C3656.2 C3657.1 C3658.2 C3661.2 C3751.2 C3752.2 C3753.2 C3754.2 C3755.2 C3756.2 C3757.2 C3758.2 C3759.2 C3760.2 C3767.2 C3773.2 C3774.1 R254.1 R545.2 R5806.2 R5830.2 U136.A1(VSS) U136.A19(VSS) U136.B2(VSS) U136.C3(VSS) U136.C19(VSS) U136.D1(VSS) U136.D3(VSS) U136.D4(VSS) U136.D8(VSS) U136.D11(VSS) U136.D14(VSS) U136.D19(VSS) U136.E5(VSS) U136.E9(VSS) U136.E10(VSS) U136.E11(VSS) U136.E12(VSS) U136.E14(VSS) U136.E15(VSS) U136.E17(VSS) U136.E18(VSS) U136.F4(VSS) U136.F10(VSS) U136.F11(VSS) U136.F14(VSS) U136.F15(VSS) U136.F16(VSS) U136.G4(VSS) U136.G6(VSS) U136.G8(VSS) U136.G9(VSS) U136.G12(VSS) U136.G13(VSS) U136.G15(VSS) U136.H3(VSS) U136.H6(VSS) U136.H11(VSS) U136.J7(VSS) U136.J11(VSS) U136.J13(VSS) U136.J15(VSS) U136.K8(VSS) U136.K11(VSS) U136.K12(VSS) U136.K15(VSS) U136.L5(VSS) U136.L7(VSS) U136.L9(VSS) U136.L10(VSS) U136.L13(VSS) U136.L14(VSS) U136.L15(VSS) U136.M5(VSS) U136.M8(VSS) U136.M12(VSS) U136.M15(VSS) U136.N5(VSS) U136.N6(VSS) U136.N7(VSS) U136.N9(VSS) U136.N13(VSS) U136.N14(VSS) U136.N15(VSS) U136.P5(VSS) U136.P6(VSS) U136.P14(VSS) U136.P15(VSS) U136.R5(VSS) U136.R6(VSS) U136.R7(VSS) U136.R10(VSS) U136.R12(VSS) U136.R13(VSS) U136.R14(VSS) U136.R15(VSS) U136.T5(VSS) U136.T8(VSS) U136.T9(VSS) U136.T10(VSS) U136.T16(VSS) U136.U4(VSS) U136.U5(VSS) U136.U8(VSS) U136.U10(VSS) U136.U17(VSS) U136.V4(VSS) U136.V10(VSS) U136.V18(VSS) U136.W1(VSS) U136.W3(VSS) U136.W6(VSS) U136.W10(VSS) U136.W19(VSS) U3086.3(GND) U3087.3(GND) Y3.2 Y3.4 Y8.2 Y8.4 ; also on sheet 1 2 12 13 14 15 16 17 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VCC1V8_SYS: C3773.1 C3774.2 R259.1 R301.1 U3086.5(VCC) U3087.5(VCC) ; also on sheet 16 22 23 24 26 27 28 29 31 34 38 39 40 42 43 44 46 47 48 52 54 56
VCC_5V0: R543.1 ; also on sheet 1 12 14 15 16 37 42 43 45
VDD_CORE: C441.1 C445.1 C448.1 C460.1 C462.1 C468.1 C477.1 C494.1 C657.1 C658.1 C659.1 C660.1 C662.1 C663.1 C3661.1 C3751.1 C3752.1 C3753.1 C3754.1 C3755.1 C3756.1 C3757.1 FL8.1 U136.G7(VDD_CORE) U136.G11(VDD_CORE) U136.G14(VDD_CORE) U136.H9(VDD_CORE) U136.H10(VDD_CORE) U136.H13(VDD_CORE) U136.J12(VDD_CORE) U136.K7(VDD_CORE) U136.K9(VDD_CORE) U136.K13(VDD_CORE) U136.L8(VDD_CORE) U136.L11(VDD_CORE) U136.L12(VDD_CORE) U136.M7(VDD_CORE) U136.M9(VDD_CORE) U136.M13(VDD_CORE) U136.P7(VDD_CORE) U136.P13(VDD_CORE) ; also on sheet 16
VDDA_1V8: C202.1 C483.1 FL6.1 FL9.1 FL13.1 FL20.1 FL21.1 FL22.1 ; also on sheet 16 33
VDDA_1V8_FB1: C463.1 C485.1 C501.1 FL13.2 U136.J9(VDDA_PLL0) U136.J10(VDDA_PLL1) U136.M11(VDDA_PLL2)
VDDA_1V8_FB2: C467.1 C3656.1 FL6.2 U136.K5(VDDA_TEMP0) U136.N11(VDDA_TEMP1)
VDDA_1V8_FB3: C3647.1 FL20.2 U136.H7(VDDA_MCU)
VDDA_1V8_FB4: C3649.1 FL21.2 U136.P10(VDDA_1P8_USB)
VDDA_1V8_FB_OSC: C508.1 FL9.2 U136.F5(VDDS_OSC0)
VDDA_ADC0: C3652.1 FL22.2 U136.J5(VDDA_ADC0)
VDDA_CORE_USB: C495.1 C497.1 C3767.1 FL8.2 U136.N10(VDDA_CORE_USB)
VDDA_SYS_MON: C449.2 R543.2 R545.1 U136.H8(VMON_ER_VSYS)
VDDR_CANUART: C3653.1 R3731.2 U136.E7(VDDR_CANUART)
VDDR_CORE: C447.1 C465.1 C466.1 C490.1 C493.1 C505.1 C3758.1 C3759.1 C3760.1 U136.G10(VDDR_CORE) U136.H12(VDDR_CORE) U136.J8(VDDR_CORE) U136.K10(VDDR_CORE) U136.M10(VDDR_CORE) U136.M14(VDDR_CORE) U136.N8(VDDR_CORE) U136.N12(VDDR_CORE) ; also on sheet 16 17
VDDSHV_SDIO: C201.1 ; also on sheet 16 29
AEC1_GPIO0_0: U136.A6(MCU_GPIO0_15) ; also on sheet 42
AEC2_GPIO0_0: U136.A9(MCU_GPIO0_4) ; also on sheet 43
AEC2_GPIO0_1: U136.B8(MCU_GPIO0_3) ; also on sheet 43
CAP_VDDS0: C454.1 U136.L6(CAP_VDDS0)
CAP_VDDS1: C434.1 U136.F13(CAP_VDDS1)
CAP_VDDS2: C446.1 U136.R11(CAP_VDDS2)
CAP_VDDS3: C432.1 U136.H15(CAP_VDDS3)
CAP_VDDS5: C443.1 U136.P8(CAP_VDDS5)
CAP_VDDS_CANUART: C509.1 U136.E6(CAP_VDDS_CANUART)
CAP_VDDS_MCU: C484.1 U136.E8(CAP_VDDS_MCU)
GPIO_MCU_SoC_INTn: U136.C8(MCU_GPIO0_2) ; also on sheet 24
IORET_WAKE: U136.D7(MCU_GPIO0_16) ; also on sheet 24
MCAN0_RX: U136.B4(MCU_GPIO0_6) ; also on sheet 45
MCAN0_TX: R82.2 U136.C4(MCU_GPIO0_5)
MCAN0_TX_R: R82.1 ; also on sheet 45
MCAN1_RX: U136.D5(MCU_GPIO0_8) ; also on sheet 43
MCAN1_TX: R5671.1 ; also on sheet 43
MCAN1_TX_R: R5671.2 U136.A4(MCU_GPIO0_7)
MCAN4_RX: U136.B6(MCU_GPIO0_14) ; also on sheet 42
MCU_GPIO0_1_INTn: U136.C7(WKUP_TIMER_IO1) ; also on sheet 24 47
MCU_OSC0_XI: R249.2 R252.2 U136.A2(MCU_OSC0_XI)
MCU_OSC0_XO: R253.2 R254.2 U136.B1(MCU_OSC0_XO)
MMC0_SDIO_VSEL: U3087.4(Y) ; also on sheet 16
MMC0_SEL_1V8: U3086.1(~{OE}) U3087.1(B) ; also on sheet 23
OSC1_XI: R3732.1 U136.C1(OSC1_XI)
OSC1_XO: R3733.1 U136.C2(OSC1_XO)
PMIC_LPM_EN0: R5750.2 TP75.1(TP) ; also on sheet 16
SoC_CLKIN: R249.1 ; also on sheet 22
SOC_DVDD1V8: C429.1 C437.1 C440.1 C453.1 C461.1 C502.1 C506.1 U136.E13(VDDSHV1) U136.F8(VDDSHV_MCU) U136.F9(VDDSHV_MCU) U136.F12(VDDSHV1) U136.H14(VDDSHV3) U136.J6(VMON_1P8_SOC) U136.J14(VDDSHV3) U136.K6(VDDSHV0) U136.K14(VDDSHV3) U136.M6(VDDSHV0) ; also on sheet 16
SOC_DVDD3V3: C451.1 C471.1 FL19.1 U136.H5(VMON_3P3_SOC) U136.P11(VDDSHV2) U136.P12(VDDSHV2) ; also on sheet 16
SoC_DVDD3V3_FB1: C3645.1 FL19.2 U136.R9(VDDA_3P3_USB)
SoC_RGMII_MDC: R548.2 ; also on sheet 35 36
SoC_RGMII_MDIO: R541.2 ; also on sheet 35 36
SOC_VDD_CANUART: C224.1 R3731.1 U136.F6(VDD_CANUART) ; also on sheet 15
SoC_VDDSHV5_SDIO: C3655.1 U136.P9(VDDSHV5) U136.R8(VDDSHV5) ; also on sheet 16
SOC_VDDSHV_CANUART: C512.1 U136.F7(VDDSHV_CANUART) ; also on sheet 15
UART3_RXD_FET: U136.C6(MCU_GPIO0_13) ; also on sheet 52
VPP_1V8: C517.1 U136.G5(VPP) ; also on sheet 15
VSEL_SD_SOC: R5751.2 R5830.1 U3086.2(A)
WKUP_I2C0_SCL: C245.1 R284.1 R301.2 ; also on sheet 16
WKUP_I2C0_SCL_RC: R284.2 U136.B9(WKUP_I2C0_SCL)
WKUP_I2C0_SDA: C248.1 R256.1 R259.2 ; also on sheet 16
WKUP_I2C0_SDA_RC: R256.2 U136.A8(WKUP_I2C0_SDA)
WKUP_LFOSCO_XI: C216.2 R568.1 U136.E1(WKUP_LFOSC0_XI) Y4.1
WKUP_LFOSCO_XO: C213.2 R261.2 R568.2 Y4.2
WKUP_UART0_CTSN: U136.D6(WKUP_UART0_CTSn) ; also on sheet 52
WKUP_UART0_RTSN: U136.C5(WKUP_UART0_RTSn) ; also on sheet 52
WKUP_UART0_RXD: U136.B5(WKUP_UART0_RXD) ; also on sheet 52
WKUP_UART0_TXD: U136.A5(WKUP_UART0_TXD) ; also on sheet 52
N21761137: R5750.1 U136.A7(PMIC_LPM_EN0)
N21784165: R548.1 U136.V11(MDIO0_MDC)
N21784176: R541.1 U136.U11(MDIO0_MDIO)
N27972730: R261.1 U136.D2(WKUP_LFOSC0_XO)
N27975044: C205.2 R252.1 Y3.1
N27975050: C209.2 R253.1 Y3.3
N27975317: C3657.2 R3733.2 Y8.1
N27975321: C3658.1 R3732.2 Y8.3
N28082506: TP586.1(TP) U136.B11(WKUP_CLKOUT0)
N28224348: R5751.1 U136.B7(WKUP_TIMER_IO0)
N28962728: R5806.1 U3086.4(Y) U3087.2(A)

## Notes on the sheets
sheet 18
- SOC POWER SUPPLIES AND SUPPLY RAILS
- 0.5V to VMON_SYS pin
- SOC VSS
sheet 19
- SOC POWER SUPPLIES - DECAPS 1
- Place 1uF cap near SoC Balls
- Place 1uF cap near SoC Balls
- Place 1uF cap near SoC Balls
- Place 1uF cap near SoC Balls
sheet 20
- SOC POWER SUPPLIES - DECAPS 2
- Peripherals - 1.8V Analog SUPPLY
- Peripherals - Core SUPPLY
- 3.3V/1.8V MMC0 SUPPLY
- VDDR_CANUART SUPPLY
- VPP_1V8
- BLM15PX121SN1D :- 120E
  2A @ 85 deg C
  1.1A @ 125 deg C
- VDDA_1V8_FB2
- VDDSHV_CANUART SUPPLY
- Peripherals - 3.3V Analog SUPPLY
- VDDA_1V8_FB3
- VDDA_1V8_FB4
- VDDA_1V8_FB4
sheet 21
- SOC WKUP DOMAIN
- ECS-.327-9-34QCS-TR
- SOC GPIO
- XRCGB25M000F3M00R0
- CAD Note: Tripad R249 - R252 & R253 - R254
- ABM3B-24.576MHz-10-1-U-T
- MMC0_SEL_1V8
- VSEL_SD_SOC
- MMC0_SDIO_VSEL
- VDDSHV_SDIO
- 0
- 0
- 0
- 3V3
- 3V3 IO routed to uSD
- 0
- 1
- 1
- 1V8
- 1V8 IO routed to uSD
- 1
- (DEFAULT)
- X
- 1
- 1V8
- 1V8 IO routed to EMMC

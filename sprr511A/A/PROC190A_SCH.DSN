# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 45 to 47 of 57

## Sheets
45 45. CAN_INTERFACE: size C; title: CAN TRANSCEIVER
46 46. BOOTMODE BUFFERS AND IO EXP: size C; title: BOOT MODE BUFFER & IO EXPANDERS
47 47. IO EXPANDER & LED: size C; title: IO EXPANDER & USER TEST LEDS

## Parts
sheet 45. CAN_INTERFACE
C1  0.022uF  [CAP0402_0-75]
C107  4700pF  [CAP0402_0-75]
C3692  0.1uF  [CAP0402_0-75]
C3694  0.1uF  [CAP0402_0-75]
C3695  4.7uF  [CAP0603_1]
C3696  4.7uF  [CAP0603_1]
C3697  0.1uF  [CAP0402_0-75]
J9  HDR_1X3  [HDR_1X3_100_S_T]
J34  HDR_1X2  [HDR_1X2_61300211121_S_T_8-6]
R81  33E  [RES0402_0-5]
R88  59E_1%  [RES0402_0-5]
R93  59E_1%  [RES0402_0-5]
R102  0E  [RES0402_0-5]
R5635  33.2K_1%  [RES0402_0-5]
R5636  3.32K_1%  [RES0402_0-5]
R5637  0E  [RES0402_0-5]
R5638  10K  [RES0402_0-5]
R5639  0E  [RES0402_0-5]
R5692  10K  [RES0402_0-5]
TP585  TP30_SMD  [TP30_SMD]
TP593  TP20_SMD  [TP20_SMD]
U3068  TCAN1043ADYYRQ1  [SOT23-14_1-1]
sheet 46. BOOTMODE BUFFERS AND IO EXP
C136  0.1uF  [CAP0201_0-5]
C391  0.1uF  [CAP0201_0-5]
C393  0.1uF  [CAP0201_0-5]
C394  0.1uF  [CAP0201_0-5]
C395  0.1uF  [CAP0201_0-5]
C408  0.1uF  [CAP0201_0-5]
C409  0.1uF  [CAP0201_0-5]
C473  0.1uF  [CAP0201_0-5]
C529  0.1uF  [CAP0201_0-5]
J10  HDR_1X2  [HDR_1X2_90120-0122_S_T_5-6]
R112  10K  [RES0201_0-5]
R377  0E  [RES0201_0-5]
R438  1K  [RES0201_0-5]
R439  10K  [RES0201_0-5]
R456  10K  [RES0201_0-5]
R457  10K  [RES0201_0-5]
R461  10K  [RES0201_0-5]
R551  4.7K  [RES0201_0-5]
R552  4.7K  [RES0201_0-5]
R578  1K  [RES0402_0-5]
R579  0E  [RES0201_0-5]
R580  0E  [RES0201_0-5]
R582  4.7K  [RES0201_0-5]
R583  4.7K  [RES0201_0-5]
R643  0E  [RES0805_0-75]
TP45  TP20_SMD  [TP20_SMD]
TP71  TP20_SMD  [TP20_SMD]
U23  SN74LVC1G08DBVRE4  [SOT23-5]
U81  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]
U82  TCA6424ARGJR  [QFN32_19-68_200X200]
U83  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]
U107  TCA9517DR  [SOIC8_1-8]
sheet 47. IO EXPANDER & LED
C99  0.1uF  [CAP0201_0-5]
C101  0.1uF  [CAP0201_0-5]
C122  0.01uF  [CAP0201_0-5]
C126  0.01uF  [CAP0201_0-5]
LD1  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
LD10  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
Q1  CSD16301Q2  [WSON6_CSD13202Q2_80X80_0-8]
Q5  CSD16301Q2  [WSON6_CSD13202Q2_80X80_0-8]
R56  4.7K  [RES0201_0-5]
R58  4.7K  [RES0201_0-5]
R69  10K  [RES0402_0-5]
R94  10K  [RES0201_0-5]
R98  10K  [RES0201_0-5]
R107  10K  [RES0201_0-5]
R108  0E  [RES0201_0-5]
R180  220E  [RES0402_0-5]
R203  10K  [RES0201_0-5]
R213  0E  [RES0402_0-5]
R440  220E  [RES0402_0-5]
R441  0E  [RES0402_0-5]
R442  10K  [RES0201_0-5]
R5761  47K_1%  [RES0402_0-5]
U11  TCA9406DCUR  [VSSOP8_19-68_85X95]
U18  TCA6416ARTWR  [WQFN24_19-68_160X160]
U21  TCA6424ARGJR  [QFN32_19-68_200X200]

## Library data of the parts
C1 = CAP: CAP CERAMIC 0.022uF 50V 10% X7R AUTO 0402; Chkd/date: MAZHAR/301208; Crtd /date: USMAN/051108; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-4763-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GCM155R71H223KA55D; Mistral Part No: 120011100036-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: P2ER6DB; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GCM155R71H223KA55.PDF
C107 = CAP: CAP CERAMIC 4700pF 50V 10% X7R 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B2X7R1H472K050BA; Chkd/date: MANIRAJA/040419; Crtd /date: MANIRAJA/040419; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: SAMSUNG; Direct Alternate_mfr_part_number: CL05B472KB5NNNC; Distributor_name: DIGIKEY; Distributor_part_number: 490-1308-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R71H472KA01D; Mistral Part No: 120009030440-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R71H472KA01.PDF
C3692 C3694 C3697 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B3X7R1H104K050BB; Chkd/date: MANIRAJA/261020; Crtd /date: ALVY/211020; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: C1005X7R1H104K050BE; Distributor_name: DIGIKEY; Distributor_part_number: 490-10700-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: MURATA; Mfr_name: MURATA; Mfr_part_number: GRM155R71H104KE14D; Mistral Part No: 120011100014-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: J7_CP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R71H104KE14.PDF
C3695 C3696 = CAP: CAP CERAMIC 4.7uF 25V 10% X6S 0603; Chkd/date: MANIRAJA/241018; Crtd /date: ALVY/241018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: MURATA; Direct Alternate_mfr_part_number: GRM188C81E475ME11D; Distributor_name: DIGIKEY; Distributor_part_number: 490-7199-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: MURATA; Mfr_name: MURATA; Mfr_part_number: GRM188C81E475KE11D; Mistral Part No: 120018100056-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: TI_J7ES_EVM_CP; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM188C81E475KE11D.PDF
J9 = HEADER_3X1: CON HDR 1X3 2.54MM PITCH ST TH; Chkd/date: VASANTHA/211015; Crtd /date: VASANTHA/211015; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5316-ND; Height: 8.54MM; Mfr_name: WURTH ELECTRONICS INC; Mfr_part_number: 61300311121; Mistral Part No: 150015100037-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: CYPHY_ROADKILL; RoHS: RoHS; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\6130XXX.PDF
J34 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: MANIRAJA/031018; Crtd /date: ALVY/031018; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5315-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 8.54MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 61300211121; Mistral Part No: 150018100003-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: ALPINE_EVM; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 120mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\6130XXX.PDF
R81 = RESISTOR: RES 33E 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P33JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ330X; Mistral Part No: 110009030699-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R88 R93 = RESISTOR: RES 59E 1/10W 1% 0402; Chkd/date: MAZHAR/151208; Crtd /date: USMAN/031208; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P59.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF59R0X; Mistral Part No: 110009031010-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: KHAN_HSST; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R102 R213 R441 R5637 R5639 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5635 = RESISTOR: RES 33.2K 1/10W 1% 0402; Chkd/date: SHREESHAIL/310506; Crtd /date: GEETHA/290506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P33.2KLTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: PANASONIC-ECG; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF3322X; Mistral Part No: 110009030682-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5636 = RESISTOR: RES 3.32K 1/16W 1% 0402; Chkd/date: MAZHAR/130709; Crtd /date: USMAN/230808; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-3.32KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: VISHAY; Mfr_name: VISHAY; Mfr_part_number: CRCW04023K32FKED; Mistral Part No: 110009030620-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: CPB; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R5638 R5692 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP585 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Manufacturer: LOCAL; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
TP45 TP71 TP593 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U3068 = TCAN1043DQ1_SOIC14: IC AUTOMOTIVE LOW-POWER FAULT PROTECTED CAN FD TRANSCEIVER WITH SLEEP MODE TSOT23-14; Chkd/date: ALVY/140422; Crtd /date: ALVY/140422; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_TELECOM_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 143022040001-R; Package: TSOT23-14; Part_type: ICS\TELECOM\TRANSCEIVER; Project: TI_AM62A SVB_BRD; RoHS: NA; Temperature: -40°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\TELECOM\TCAN1043-Q1.PDF
C136 C394 C395 C408 C409 C473 C529 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C99 C101 C391 C393 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
J10 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: NAVEED/210714; Crtd /date: USMAN/031012; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM8072-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 5.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 90120-0122; Mistral Part No: 150012100005-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: NPOL_FEP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 122mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\90120-XX.PDF
R94 R98 R107 R112 R203 R439 R442 R456 R457 R461 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R108 R377 R579 R580 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R438 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R56 R58 R551 R552 R582 R583 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R578 = RESISTOR: RES 1K 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.0KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ102X; Mistral Part No: 110009030400-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R643 = RESISTOR: RES 0E 1/8W 5% 0805; Chkd/date: VASANTHA/130416; Crtd /date: JEBRAN/020316; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0ARCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0805JR-070RL; Mistral Part No: 110009030074-R; Package: 0805; Part_type: RESISTORS\FIXED; Project: ZK_BIOMETRIC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/8W; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U23 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
U81 U83 = SN74AVC8T245RHL_QFN24: IC BUS TRANSCEIVER 8-BIT DUAL-SUPPLY QFN24; Chkd/date: VASANTHA/231216; Crtd /date: BAVISH/290411; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-17859-1-ND; Height: 1.00MM; Mfr_name: TEXAS INSTRUMENTS; Mfr_part_number: SN74AVC8T245RHLR; Mistral Part No: 143011040001-R; Package: QFN24; Part_type: ICS\TELECOM\TRANSCEIVER; Project: OMAPL1_PEC20; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\SN74AVC8T245.PDF
U21 U82 = TCA6424ARGJR_QFN32: IC I2C I/O EXPANDER 24B UQFN32; Chkd/date: NAVEED/100715; Crtd /date: NAVEED/100914; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-27844-1-ND; Height: 0.60MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141014090009-R; Package: UQFN32; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: ZK_BIOMETRIC; RoHS: RoHS; Temperature: -40°C+85°C; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\TCA6424AR.PDF
U107 = TCA9517DGKR_VSSOP8: IC 2-CHANNEL BI-DIR LEVEL-SHIFTING I2C BUS REPEATER SOIC8; Chkd/date: MANIRAJA/171121; Crtd /date: ALVY/161121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-39221-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.75MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021110017-R; Package: SOIC8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: EXCITER MULTI-CH RX UNIT; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 540mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TCA9517.PDF
C122 C126 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
LD1 LD10 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
Q1 Q5 = MOSFET_CSD17313Q2: IC MOSFET N-CHANNEL NEXFET 25V WSON6; Chkd/date: ALVY/071220; Crtd /date: MANIRAJA/071220; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-25260-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Manufacturer: TEXAS INSTRUMENTS; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142020120008-R; Package: WSON6; Part_type: ICS\POWER\MOSFET; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 8.7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\CSD16301Q2.PDF
R69 = RESISTOR: RES 10K 1/16W 5% 0402; Assembly_Instruction: DNI; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R180 R440 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R5761 = RESISTOR: RES 47K 1/16W 1% 0402; Chkd/date: VASANTHA/060117; Crtd /date: MAZHAR/141206; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-47.0KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0747KL; Mistral Part No: 110009030884-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U11 = TCA9406DCUR_VSSOP8: IC VOLTAGE-LEVEL TRANSLATOR 2BIT BIDIRECTIONAL VSSOP8; Chkd/date: USMAN/190612; Crtd /date: BAVISH/210611; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-28109-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011060026-R; Package: VSSOP8; Part_type: ICS\INTERFACE; Project: SVDU; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TCA9406.PDF
U18 = TCA6416ARTWR_WQFN24: IC I2C I/O EXPANDER 16Bit WQFN24; Chkd/date: VASANTHA/011016; Crtd /date: VASANTHA/011016; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24826-1-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016100001-R; Package: WQFN24; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: OCTBTS5200_FEM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\TCA6416.PDF

## Nets
DGND: C1.2 C99.2 C101.2 C107.2 C122.1 C126.1 C136.2 C391.1 C393.1 C394.1 C395.2 C408.2 C409.1 C473.1 C529.1 C3692.1 C3694.2 C3695.1 C3696.2 C3697.1 J9.2 J34.2 Q1.4(S1) Q1.7(S2) Q5.4(S1) Q5.7(S2) R94.2 R107.2 R112.1 R203.1 R438.1 R442.1 R456.2 U11.2(GND) U18.9(GND) U18.25(PAD) U21.25(GND) U21.33(EP) U23.3(GND) U81.11(GND1) U81.12(GND2) U81.13(GND3) U81.25(EP) U82.25(GND) U82.33(EP) U83.11(GND1) U83.12(GND2) U83.13(GND3) U83.25(EP) U107.4(GND) U3068.2(GND) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 37 38 39 40 41 42 43 44 48 49 50 51 52 53 54 55 56
VCC1V8_SYS: C101.1 C126.2 C395.1 C408.1 R69.1 R5761.1 U11.3(VCCA) U21.27(VCCP) U21.31(VCC) U81.23(VCCB1) U81.24(VCCB2) U83.23(VCCB1) U83.24(VCCB2) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 38 39 40 42 43 44 48 52 54 56
VCC1V8_TA: C136.1 C391.2 C393.2 C394.2 C409.2 C529.2 R439.2 R457.2 R461.2 R578.1 R582.1 R583.1 R643.2 U23.5(VCC) U81.1(VCCA) U82.27(VCCP) U82.31(VCC) U83.1(VCCA) U107.1(VCCA) ; also on sheet 25 55
VCC3V3_XDS: C473.2 R551.1 R552.1 U107.8(VCCB) ; also on sheet 31 53 54 55
VCC_3V3_SYS: C99.1 C122.2 R56.1 R58.1 R98.2 R180.2 R440.2 U11.7(VCCB) U18.21(VCCP) U18.23(VCCI) ; also on sheet 1 2 12 16 17 23 28 29 31 34 35 36 38 40 44 48 49 50 55 56
VCC_5V0: C3692.2 C3695.2 U3068.3(VCC) ; also on sheet 1 12 14 15 16 18 37 42 43
VDDSHV_CANUART: C3694.1 C3696.1 R643.1 R5638.2 R5692.2 U3068.5(VIO) ; also on sheet 14 15 16 17 23 24 52
ADDR0_IO_EXP: R107.1 U21.26(ADDR)
ADDR1_IO_EXP: R94.1 U18.18(ADDR)
AEC1_REFCLK_SEL: U21.23(P26) ; also on sheet 34
AEC2_REFCLK_SEL: U21.24(P27) ; also on sheet 34
AUDIO_EXT_REFCLK2_S0: U21.21(P24) ; also on sheet 34
AUDIO_EXT_REFCLK2_S1: U21.22(P25) ; also on sheet 34
BOOTMODE0: U81.14(B8) ; also on sheet 25
BOOTMODE1: U81.15(B7) ; also on sheet 25
BOOTMODE2: U81.16(B6) ; also on sheet 25
BOOTMODE3: U81.17(B5) ; also on sheet 25
BOOTMODE4: U81.18(B4) ; also on sheet 25
BOOTMODE5: U81.19(B3) ; also on sheet 25
BOOTMODE6: U81.20(B2) ; also on sheet 25
BOOTMODE7: U81.21(B1) ; also on sheet 25
BOOTMODE8: U83.14(B8) ; also on sheet 25
BOOTMODE9: U83.15(B7) ; also on sheet 25
BOOTMODE10: U83.16(B6) ; also on sheet 25
BOOTMODE11: U83.17(B5) ; also on sheet 25
BOOTMODE12: U83.18(B4) ; also on sheet 25
BOOTMODE13: U83.19(B3) ; also on sheet 25
BOOTMODE14: U83.20(B2) ; also on sheet 25
BOOTMODE15: U83.21(B1) ; also on sheet 25
BOOTMODE_I2C_EN: R578.2 U107.5(EN)
BOOTMODE_I2C_SCL: R579.1 R583.2 TP71.1(TP) U82.29(SCL)
BOOTMODE_I2C_SDA: R580.1 R582.2 TP45.1(TP) U82.30(SDA)
BOOTMODEON: R112.2 U23.4(Y) U81.22(~{OE}) U83.22(~{OE})
BUF_BOOTMODE_I2C_SCL: R552.2 U107.7(SCLB) ; also on sheet 53
BUF_BOOTMODE_I2C_SDA: R551.2 U107.6(SDAB) ; also on sheet 53
CAN-FD_INH: TP585.1(TP) U3068.7(INH) ; also on sheet 14
DIR: R461.1 U81.2(DIR) U83.2(DIR)
GPIO_CPSW1_RST: U18.11(P11) ; also on sheet 35
GPIO_CPSW2_RST: U18.10(P10) ; also on sheet 36
GPIO_eMMC_RSTn: U21.9(P10) ; also on sheet 28
GPIO_PCM1_RST: U21.17(P20) ; also on sheet 40
GPIO_PCM2_RST: U21.19(P22) ; also on sheet 41
I2C0_SCL_1V8: U11.5(SCL_A) U21.29(SCL) ; also on sheet 16 22 31 38 39 40 41 48
I2C0_SDA_1V8: U11.4(SDA_A) U21.30(SDA) ; also on sheet 16 22 31 38 39 40 41 48
IO_EXP0_INTn: R108.2 R5761.2 U21.32(~{INT})
IO_EXP1_INTn: R98.1 U18.22(~{INT})
IO_EXP_ADDR: R456.1 U82.26(ADDR)
IO_EXP_TEST_LED: R441.1 U18.12(P12)
IO_MCAN0_EN: R5639.2 U21.10(P11)
IO_MCAN0_STB#: R102.2 R5692.1 U21.12(P13)
MCAN0_CAN_H: J9.3 R88.2 U3068.13(CANH)
MCAN0_CAN_L: J9.1 R93.1 U3068.12(CANL)
MCAN0_EN: R5638.1 R5639.1 U3068.6(EN)
MCAN0_FAULT#: R5637.1 U3068.8(nFAULT)
MCAN0_RX: R81.1 ; also on sheet 21
MCAN0_RX_R: R81.2 U3068.4(RxD)
MCAN0_STB#: R102.1 U3068.14(nSTB)
MCAN0_T: C107.1 R88.1 R93.2
MCAN0_TX_R: U3068.1(TxD) ; also on sheet 21
MCAN0_WAKE_R: R5635.1 U3068.9(WAKE)
McASP4_FET_SEL: U18.4(P03) ; also on sheet 44
MCU_GPIO0_1_INTn: R108.1 ; also on sheet 21 24
MMC0_FET_EN: U18.3(P02) ; also on sheet 2
MMC0_SD_EN: U21.4(P03) ; also on sheet 29
MMC0_SEL_IO: U18.17(P17) ; also on sheet 2
PCM1_INT_1V8: U21.15(P16) ; also on sheet 40
PCM2_INT_1V8: U21.16(P17) ; also on sheet 41
PD_I2C_IRQ: U18.6(P05) ; also on sheet 12
RESETSTATz: U18.24(~{RESET}) ; also on sheet 31 35 36
RESETSTATZ_1V8: R377.2 U21.28(~{RESET}) ; also on sheet 22 23 26 27 28 29 31 40 41 42 43
SOC_GPIO0_38: R213.1 ; also on sheet 30
SoC_I2C0_SCL: R56.2 U11.8(SCL_B) U18.19(SCL) ; also on sheet 12 35 36 48 49 50 55
SoC_I2C0_SDA: R58.2 U11.1(SDA_B) U18.20(SDA) ; also on sheet 12 35 36 48 49 50 55
SYS_BOOTMODE0: U81.10(A8) U82.1(P00) ; also on sheet 25
SYS_BOOTMODE1: U81.9(A7) U82.2(P01) ; also on sheet 25
SYS_BOOTMODE2: U81.8(A6) U82.3(P02) ; also on sheet 25
SYS_BOOTMODE3: U81.7(A5) U82.4(P03) ; also on sheet 25
SYS_BOOTMODE4: U81.6(A4) U82.5(P04) ; also on sheet 25
SYS_BOOTMODE5: U81.5(A3) U82.6(P05) ; also on sheet 25
SYS_BOOTMODE6: U81.4(A2) U82.7(P06) ; also on sheet 25
SYS_BOOTMODE7: U81.3(A1) U82.8(P07) ; also on sheet 25
SYS_BOOTMODE8: U82.9(P10) U83.10(A8) ; also on sheet 25
SYS_BOOTMODE9: U82.10(P11) U83.9(A7) ; also on sheet 25
SYS_BOOTMODE10: U82.11(P12) U83.8(A6) ; also on sheet 25
SYS_BOOTMODE11: U82.12(P13) U83.7(A5) ; also on sheet 25
SYS_BOOTMODE12: U82.13(P14) U83.6(A4) ; also on sheet 25
SYS_BOOTMODE13: U82.14(P15) U83.5(A3) ; also on sheet 25
SYS_BOOTMODE14: U82.15(P16) U83.4(A2) ; also on sheet 25
SYS_BOOTMODE15: U82.16(P17) U83.3(A1) ; also on sheet 25
SYSBOOT_BUF_ENz: R377.1 U23.1(A)
TCA6424_EXP_INT: R457.1 U82.32(~{INT})
TEST_GPIO2: U21.18(P21) ; also on sheet 55
TEST_GPIO3: J10.1 R439.1 U23.2(B) ; also on sheet 55
TEST_GPIO4: U82.28(~{RESET}) ; also on sheet 55
UART2_FET_SEL: U21.13(P14) ; also on sheet 52
UART3_FET_SEL: U21.14(P15) ; also on sheet 52
VMAIN: C3697.2 R5636.1 U3068.10(VSUP) ; also on sheet 13 14
VPP_EN: U21.5(P04) ; also on sheet 15
N17078974: J10.2 R438.2
N27173972: Q1.3(G) R203.2 R213.2
N27173989: Q5.3(G) R441.2 R442.2
N27174010: LD10.1(CATHODE) Q5.1(D1) Q5.2(D2) Q5.5(D3) Q5.6(D4) Q5.8(D5)
N27174034: LD1.1(CATHODE) Q1.1(D1) Q1.2(D2) Q1.5(D3) Q1.6(D4) Q1.8(D5)
N27174097: LD1.2(ANODE) R180.1
N27174144: LD10.2(ANODE) R440.1
N27248134: R579.2 U107.2(SCLA)
N27248136: R580.2 U107.3(SDAA)
N28044811: C1.1 J34.1 R5635.2 R5636.2
N28049053: R69.2 U11.6(OE)
N28248996: R5637.2 TP593.1(TP)

Not connected (* = marked no-connect by the designer): U18 1(P00)* 2(P01)* 5(P04)* 7(P06)* 8(P07)* 13(P13)* 14(P14)* 15(P15)* 16(P16)*; U21 1(P00)* 2(P01)* 3(P02)* 6(P05)* 7(P06)* 8(P07)* 11(P12)* 20(P23)*; U82 17(P20)* 18(P21)* 19(P22)* 20(P23)* 21(P24)* 22(P25)* 23(P26)* 24(P27)*; U3068 11(NC)*

## Notes on the sheets
sheet 45
- CAN TRANSCEIVER
- CAN WITH WAKEUP FUNCTION
- 120E
- From GPIO  EXP
- Note:TCAN1043A has integrated pull down on EN & nSTB pins
sheet 46
- BOOTMODE BUFFERS AND IO EXPANDERS
- BOOT MODE BUFFERS
- DIR = H: A -> B
  DIR = L: B -> A
  OE = H: output = Hi-Z
- DIR = H: A -> B
  DIR = L: B -> A
  OE = H: output = Hi-Z
- Bootmode buffers are optional.
  A pullup and pulldown resistor can be used
  to set the BOOTMODE input state prior to
  MCU_PORz release.
- TEST AUTOMATION SUPPLY
- BOOTMODE IO EXPANDER
- BOOTMODE I2C BUS BUFFER
- I2C ADDRESS: 0x22
sheet 47
- IO EXPANDER
- Note : MMC0_SD_EN, VPP_EN
  Connect to an SOC GPIO when IO expander is not used
- I2C ADDRESS: 0x22
- I2C ADDRESS: 0x20
- USER TEST LEDS
- I2C LEVEL TRANSLATOR
- SoC GPIO
- IO EXP GPIO

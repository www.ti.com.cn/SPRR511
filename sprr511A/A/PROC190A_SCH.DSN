# OrCAD Capture schematic PROC190A_SCH.DSN, sheets 37 to 38 of 57

## Sheets
37 38. USB0 TYPE-C DRP: size C; title: USB0 TYPE-C DRP
38 39. AUDIO LINEOUT - 1: size C; title: AUDIO - STEREO LINEOUT - 1

## Parts
sheet 38. USB0 TYPE-C DRP
C317  47uF  [CAP0805_1-5]
C318  47uF  [CAP0805_1-5]
C638  0.1uF  [CAP0201_0-5]
C639  0.1uF  [CAP0201_0-5]
C640  1uF  [CAP0201_0-5]
C646  10uF  [CAP0603_1]
C647  10uF  [CAP0603_1]
C649  0.01uF  [CAP0201_0-5]
C650  0.01uF  [CAP0201_0-5]
C651  1000pF  [CAP1206_1-75]
C652  0.01uF  [CAP0201_0-5]
C653  0.01uF  [CAP0201_0-5]
D6  BZX84C6V8LT1G  [SOT23-123_1-2]
D8  TPD1E01B04DPLT  [DIO_DFN0201_0-4]
D9  ESD122DMXR  [X2SON3_ESD122DMX_30X40_0-4]
D16  TPD1E01B04DPLT  [DIO_DFN0201_0-4]
J25  CON_USB-C_24_F  [CON_USBC24_2012670_S_R_S_3-9]
L10  90E  [IND4_DLW21H_90X60_SMD_1-4]
LD9  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
Q8  CSD25310Q2  [SON6_CSD17313Q2_80X80]
Q9  CSD25310Q2  [SON6_CSD17313Q2_80X80]
Q10  CSD16301Q2  [WSON6_CSD13202Q2_80X80_0-8]
R398  16.5K_1%  [RES0402_0-5]
R399  0E  [RES0402_0-5]
R400  0E  [RES0402_0-5]
R401  3.48K_1%  [RES0201_0-5]
R402  470E  [RES0402_0-5]
R403  0E  [RES0603_0-75]
R560  10K_1%  [RES0201_0-5]
R669  1K  [RES0402_0-5]
R672  100K  [RES0402_0-5]
R673  0E  [RES0201_0-5]
R675  10K_1%  [RES0201_0-5]
R676  10K_1%  [RES0201_0-5]
R677  1K  [RES0201_0-5]
R680  1K  [RES0201_0-5]
TP108  TP20_SMD  [TP20_SMD]
U132  TVS2200DRVR  [SON6_25-59_85X85_0-8]
sheet 39. AUDIO LINEOUT - 1
C22  1uF  [CAP0201_0-5]
C23  1uF  [CAP0201_0-5]
C24  47uF  [CAP0805_1-5]
C25  47uF  [CAP0805_1-5]
C29  0.1uF  [CAP0201_0-5]
C32  10uF  [CAP0402_0-75]
C38  1uF  [CAP0201_0-5]
C42  10uF  [CAP0402_0-75]
C45  0.1uF  [CAP0201_0-5]
C47  0.1uF  [CAP0201_0-5]
C50  0.1uF  [CAP0201_0-5]
C56  0.1uF  [CAP0201_0-5]
C61  0.1uF  [CAP0201_0-5]
C66  1uF  [CAP0201_0-5]
C72  0.1uF  [CAP0201_0-5]
C75  10uF  [CAP0402_0-75]
C343  1uF  [CAP0201_0-5]
C344  1uF  [CAP0201_0-5]
C347  47uF  [CAP0805_1-5]
C348  47uF  [CAP0805_1-5]
C350  10uF  [CAP0402_0-75]
C352  0.1uF  [CAP0201_0-5]
C354  1uF  [CAP0201_0-5]
C356  10uF  [CAP0402_0-75]
C358  0.1uF  [CAP0201_0-5]
C360  0.1uF  [CAP0201_0-5]
C362  0.1uF  [CAP0201_0-5]
C365  0.1uF  [CAP0201_0-5]
C367  0.1uF  [CAP0201_0-5]
C370  1uF  [CAP0201_0-5]
C372  0.1uF  [CAP0201_0-5]
C374  10uF  [CAP0402_0-75]
FL1  120E  [EMIFIL_BLM18P_0603_0-8]
J3  CON_AUDIOJACK6_STX-4235  [CON_AV6_STX-4235-3-3_S_R_T_26]  (sections A,B)
R24  0E  [RES0201_0-5]
R29  10K  [RES0201_0-5]
R31  10K  [RES0201_0-5]
R33  10K  [RES0201_0-5]
R36  4.7K  [RES0201_0-5]
R37  0E  [RES0201_0-5]
R418  1K  [RES0402_0-5]
R419  1K  [RES0402_0-5]
R421  0E  [RES0201_0-5]
R422  1K  [RES0402_0-5]
R423  1K  [RES0402_0-5]
R429  10K  [RES0201_0-5]
R5641  0E  [RES0402_0-5]
R5642  0E  [RES0402_0-5]
TP12  TP30_SMD  [TP30_SMD]
TP17  TP30_SMD  [TP30_SMD]
TP18  TP30_SMD  [TP30_SMD]
TP22  TP30_SMD  [TP30_SMD]
TP109  TP30_SMD  [TP30_SMD]
TP112  TP30_SMD  [TP30_SMD]
TP113  TP30_SMD  [TP30_SMD]
TP115  TP30_SMD  [TP30_SMD]
U5  TAD5212IRGER  [QFN24_TAD5212IRGER_160X160_1]
U77  TAD5212IRGER  [QFN24_TAD5212IRGER_160X160_1]

## Library data of the parts
C24 C25 C317 C318 C347 C348 = CAP: CAP CERAMIC 47uF 10V 20% X5R 0805; Chkd/date: MANIRAJA/181018; Crtd /date: ALVY/181018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-9961-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM21BR61A476ME15L; Mistral Part No: 120014100011-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: RFID_MODULE-DESIGN; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 9.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM21BR61A476ME15L.PDF
C29 C45 C47 C50 C56 C61 C72 C352 C358 C360 C362 C365 C367 C372 C638 C639 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C22 C23 C38 C66 C343 C344 C354 C370 C640 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C646 C647 = CAP: CAP CERAMIC 10uF 25V 20% X5R AUTO 0603; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT188R61E106ME13; Mistral Part No: 120022060023-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT188R61E106ME13.PDF
C649 C650 C652 C653 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
C651 = CAP: CAP CERAMIC 1000pF 2KV 10% X7R 1206; Chkd/date: SHREESHAIL/291106; Crtd /date: MAZHAR/281106; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-2956-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.52MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 1206GC102KAT1A; Mistral Part No: 120015080006-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 2KV; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_HV-MLC.PDF
D6 = DIODE_ZENER_SOT23_13: DIODE ZENER 250mW 6.8V SOT23-123; Chkd/date: MANIRAJA/031017; Crtd /date: MANIRAJA/031017; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: BZX84C6V8LT1GOSCT-ND; Height: 1.11MM; Mfr_name: ON SEMICONDUCTOR; Mistral Part No: 130017100002-R; Package: SOT23-123; Part_type: DIODE\ZENER; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -65°C+150°C; Tolerance: NA; Voltage: 6.8V; Wattage: NA; Weight: 8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\BZX84XX.PDF
D8 D16 = DIODE_TVS_DUAL: DIODE 1CH ESD PROTECTION FOR USB TYPE-C AND THUNDERBOLT3 X2SON2; Chkd/date: MANIRAJA/230920; Crtd /date: ALVY/230920; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: 296-44484-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.32MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130020090037-R; Package: X2SON2; Part_type: DIODE\TVS; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\TPD1E01B04.PDF
D9 = DIODE_ESD122DMXR: DIODE 2-CH ESD PROTECTION FOR USB TYPE-C AND HDMI 2.0 X2SON-3; Chkd/date: MANIRAJA/140817; Crtd /date: MANIRAJA/140817; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: ESD122DMXR-ND; Height: 0.40MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130017080015-R; Package: X2SON-3; Part_type: DIODE\TVS; Project: TI_SVB_CONTROLLER CARD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\DIODES\ESD122XX.PDF
J25 = CON_USB-C_24_1240183621: CON USB-C TYPE 24POS FEMALE RT SMD; Chkd/date: MANIRAJA/050618; Crtd /date: ALVY/040618; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM17992CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 3.86MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 2012670005; Mistral Part No: 150018060002-R; Package: SMD; Part_type: CONNECTOR\USB; Project: TI_J7SVB_USB_ADD-ON-CARD; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 0.686g; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\2012670X.PDF
L10 = INDUCTOR_DLW31S: IND COMMON MODE CHOKE 90E 280mA SMD; Chkd/date: MANIRAJA/270619; Crtd /date: MANIRAJA/270619; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: DLW21SZ900HQ2B; Mistral Part No: 130019060035-R; Package: SMD; Part_type: INDUCTOR; Project: TI_J7ES_CP; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 11mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\DLW21SZ900HQ2B.PDF
LD9 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
Q8 Q9 = MOSFET_CSD25310Q2: IC MOSFET P-CHANNEL WSON6; Chkd/date: VASANTHA/191215; Crtd /date: VASANTHA/191215; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-38915-1-ND; Height: 0.85MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142015120011-R; Package: WSON6; Part_type: ICS\POWER\MOSFET; Project: DUET BOARD; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\CSD25310Q2.PDF
Q10 = MOSFET_CSD17313Q2: IC MOSFET N-CHANNEL NEXFET 25V WSON6; Chkd/date: ALVY/071220; Crtd /date: MANIRAJA/071220; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-25260-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142020120008-R; Package: WSON6; Part_type: ICS\POWER\MOSFET; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 8.7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\CSD16301Q2.PDF
R398 = RESISTOR: RES 16.5K 1/16W 1% 0402; Chkd/date: ALVY/091220; Crtd /date: MANIRAJA/091220; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: YAG3002CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0716K5L; Mistral Part No: 110020120011-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R399 R400 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R401 = RESISTOR: RES 3.48K 1/20W 1% 0201; Chkd/date: PRADEEP/281123; Crtd /date: TAMILARASU/071123; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: P122951CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-1GNF3481C; Mistral Part No: 110023110006-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: AM62P SK; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 0.01; Voltage: NA; Wattage: 1/20W; Weight: 0.15mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_DEC22.PDF
R402 = RESISTOR: RES 470E 1/10W 5% 0402; Chkd/date: SHREESHAIL/24050; Crtd /date: MAZHAR/260706; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P470JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ471X; Mistral Part No: 110009030859-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: POWERBOX; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R403 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: PANASONIC-ECG; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R560 = RESISTOR: RES 10K 1/20W 1% 0201; Chkd/date: VASANTHA/270117; Crtd /date: MANIRAJA/270117; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10.0KMCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201FR-0710KL; Mistral Part No: 110011040018-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 1%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R418 R419 R422 R423 R669 = RESISTOR: RES 1K 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.0KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ102X; Mistral Part No: 110009030400-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R672 = RESISTOR: RES 100K 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ104X; Mistral Part No: 110009030177-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R24 R37 R421 R673 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R675 R676 = RESISTOR: RES 10K 1/20W 1% 0201; Chkd/date: MANIRAJA/260618; Crtd /date: ALVY/260618; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-10.0KABCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020110K0FNED; Mistral Part No: 110018060032-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: NEXTNAV_LPRX_BOARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
R677 R680 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP108 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U132 = TVS2200_WSON6: IC 22V FLAT-CLAMP SURGE PROTECTION DEVICE WSON6; Chkd/date: MANIRAJA/011021; Crtd /date: ALVY/011021; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-52187-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCPOWER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142021100001-R; Package: WSON6; Part_type: ICS\POWER; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 12mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TVS2200.PDF
C32 C42 C75 C350 C356 C374 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
FL1 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 3A 0603; Chkd/date: MANIRAJA/251018; Crtd /date: ALVY/251018; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 490-13261-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.75MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM18KG121TH1D; Mistral Part No: 130018100051-R; Package: 0603; Part_type: INDUCTOR; Project: TI_J7ES_EVM_SOM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 4mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM18XX-H1D-SER.PDF
J3 = CON_AUDIOJACK6_STX-4235-3_3: CON AUDIO JACK DUAL 6POS 3.50MM FEMALE RT TH; Chkd/date: MANIRAJA/090818; Crtd /date: ALVY/080818; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: MOUSER; Distributor_part_number: 806-STX-4235-3/3-N; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 26.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Library Ref: CON_AUDIOJACK6_STX-4235-3/3; Mfr_name: KYCON; Mfr_part_number: STX-4235-3/3-N; Mistral Part No: 150018080005-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_FUSION2_SER_CAP; RoHS: RoHS; Temperature: -25°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\STX-4235-3-3-N.PDF
R29 R31 R33 R429 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R36 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R5641 R5642 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP12 TP17 TP18 TP22 TP109 TP112 TP113 TP115 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U5 U77 = TAD5212IRGER_QFN24: IC HIGH-PERFORMANCE STEREO AUDIO WITH 115db DYNAMIC RANGE DAC QFN24; Chkd/date: PRADEEP/271223; Crtd /date: TAMILARASU/271223; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141023120021-R; Package: QFN24; Part_type: ICS\DIGITAL\DSP; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DSP\TAD5212IRGER.PDF

## Nets
AVDD_3V3_DAC: C29.1 C32.1 C350.1 C352.1 FL1.2 R29.1 R33.1 U5.23(AVDD) U77.23(AVDD) ; also on sheet 39
DGND: C22.1 C23.1 C29.2 C32.2 C38.2 C42.2 C45.2 C47.2 C50.2 C56.2 C61.2 C66.2 C72.2 C75.2 C343.1 C344.1 C350.2 C352.2 C354.2 C356.2 C358.2 C360.2 C362.2 C365.2 C367.2 C370.2 C372.2 C374.2 C646.2 C647.2 C649.2 C650.2 C651.2 C652.2 C653.2 D6.1(A) D8.2(ANODE) D9.1(GND) D16.2(ANODE) J3.1A J3.1B J25.A1(GND) J25.A12(GND) J25.B1(GND) J25.B12(GND) LD9.1(CATHODE) Q10.4(S1) Q10.7(S2) R31.2 R36.1 R37.1 R403.2 R418.1 R422.1 R429.2 R560.2 R672.2 U5.25(EP_PAD) U5.A1(VSS) U5.A2(VSS) U5.A3(VSS) U5.A4(VSS) U77.25(EP_PAD) U77.A1(VSS) U77.A2(VSS) U77.A3(VSS) U77.A4(VSS) U132.1(GND) U132.2(GND) U132.3(GND) U132.7(GND) ; also on sheet 1 2 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 31 32 33 34 35 36 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
VBUS_TYPEC2: C638.1 C646.1 C647.1 C649.1 C650.1 C652.1 C653.1 J25.A4(VBUS1) J25.A9(VBUS2) J25.B4(VBUS3) J25.B9(VBUS4) Q8.4(D1) Q8.7(D2) R401.2 R402.1 R675.1 TP108.1(TP) U132.4(IN1) U132.5(IN2) U132.6(IN3) ; also on sheet 12 16
VCC1V8_SYS: C72.1 C75.1 C372.1 C374.1 R419.2 R423.2 U5.6(IOVDD) U77.6(IOVDD) ; also on sheet 16 21 22 23 24 26 27 28 29 31 34 39 40 42 43 44 46 47 48 52 54 56
VCC_3V3_SYS: FL1.1 ; also on sheet 1 2 12 16 17 23 28 29 31 34 35 36 40 44 47 48 49 50 55 56
VCC_5V0: C317.1 C318.1 C639.1 Q9.4(D1) Q9.7(D2) R676.1 ; also on sheet 1 12 14 15 16 18 42 43 45
I2C0_SCL_1V8: U5.7(SCL) U77.7(SCL) ; also on sheet 16 22 31 39 40 41 47 48
I2C0_SDA_1V8: U5.8(SDA) U77.8(SDA) ; also on sheet 16 22 31 39 40 41 47 48
P2_PP_EXT_ENABLE: R669.1 ; also on sheet 12
SoC_USB0_DM: L10.4(OUT2) R400.1 ; also on sheet 32
SoC_USB0_DP: L10.1(IN1) R399.1 ; also on sheet 32
SoC_USB0_DRVVBUS_3V3: R673.1 ; also on sheet 12 23
SoC_USB0_VBUS: R398.1 R560.1 ; also on sheet 32
TAD1_ADDR1: R29.2 R37.2 U5.13(ADDR)
TAD1_DREG_OUT: C42.1 C45.1 U5.1(DREG)
TAD1_GPI1: R31.1 U5.12(GPI1)
TAD1_MICBIAS: C66.1 U5.14(MICBIAS)
TAD1_VREF: C38.1 U5.24(VREF)
TAD2_ADDR2: R33.2 R36.2 U77.13(ADDR)
TAD2_DREG_OUT: C356.1 C358.1 U77.1(DREG)
TAD2_GPI1: R429.1 U77.12(GPI1)
TAD2_MICBIAS: C370.1 U77.14(MICBIAS)
TAD2_VREF: C354.1 U77.24(VREF)
TAD5212_1_DIN: R5641.2 U5.5(DIN)
TAD5212_2_DIN: R5642.2 U77.5(DIN)
TAD5212_McASP1_ACLKX: R418.2 R419.1 U5.2(BCLK) U77.2(BCLK) ; also on sheet 30 39
TAD5212_McASP1_AFSX: R422.2 R423.1 U5.3(FSYNC) U77.3(FSYNC) ; also on sheet 30 39
TAD5212_McASP1_AXR1: R5641.1 R5642.1 ; also on sheet 30 39
USB_TYPEC2_EARTH: C651.1 J25.SH1 J25.SH2 J25.SH3 J25.SH4 R403.1
USBC_CONN2_CC1: D8.1(CATHODE) J25.A5(CC1) ; also on sheet 12
USBC_CONN2_CC2: D16.1(CATHODE) J25.B5(CC2) ; also on sheet 12
USBC_CONN2_DM: D9.3(IO2) J25.A7(D-_1) J25.B7(D-_2) L10.3(OUT1) R400.2
USBC_CONN2_DP: D9.2(IO1) J25.A6(D+_1) J25.B6(D+_2) L10.2(IN2) R399.2
N17031262: LD9.2(ANODE) R402.2
N24847876: R421.1 U77.4(DOUT)
N24847884: C348.1 J3.5B
N24847886: C347.1 J3.2B
N24847888: C347.2 U77.21(OUT2P)
N24847892: C344.2 U77.19(OUT1M)
N24847894: C343.2 U77.22(OUT2M)
N24847910: C348.2 U77.20(OUT1P)
N24847912: TP113.1(TP) U77.11(GPO1)
N24847957: C367.1 U77.15(IN1P)
N24847963: C365.1 U77.16(IN1M)
N24847969: C362.1 U77.17(IN2P)
N24847975: C360.1 U77.18(IN2M)
N24847993: TP112.1(TP) U77.9(GPIO1)
N24847995: TP115.1(TP) U77.10(GPIO2)
N24848039: R24.1 U5.4(DOUT)
N24848041: C25.1 J3.5A
N24848043: C24.1 J3.2A
N24848045: C24.2 U5.21(OUT2P)
N24848047: C23.2 U5.19(OUT1M)
N24848049: C22.2 U5.22(OUT2M)
N24848518: C25.2 U5.20(OUT1P)
N24848523: TP18.1(TP) U5.11(GPO1)
N24848568: C61.1 U5.15(IN1P)
N24848574: C56.1 U5.16(IN1M)
N24848580: C50.1 U5.17(IN2P)
N24848586: C47.1 U5.18(IN2M)
N24848600: R24.2 TP12.1(TP)
N24848612: R421.2 TP109.1(TP)
N24848616: TP17.1(TP) U5.9(GPIO1)
N24848618: TP22.1(TP) U5.10(GPIO2)
N27161108: D6.3(C) R398.2 R401.1
N27162147: C640.1 Q8.1(S1) Q8.2(S2) Q8.5(S3) Q8.6(S4) Q8.8(S5) Q9.1(S1) Q9.2(S2) Q9.5(S3) Q9.6(S4) Q9.8(S5) R680.1
N27162183: C317.2 C318.2 C638.2 C639.2 C640.2 Q8.3(G) Q9.3(G) R675.2 R676.2 R677.1 R680.2
N27162293: Q10.1(D1) Q10.2(D2) Q10.5(D3) Q10.6(D4) Q10.8(D5) R677.2
N27162479: Q10.3(G) R669.2 R672.1 R673.2

Not connected (* = marked no-connect by the designer): D6 2(NC)*; J25 A2(TX1+)* A3(TX1-)* A8(SBU1)* A10(RX2-)* A11(RX2+)* B2(TX2+)* B3(TX2-)* B8(SBU2)* B10(RX1-)* B11(RX1+)*

## Notes on the sheets
sheet 37
- USB0 TYPE-C DRP
- Silk: TYPE-C DRP
- Bypass option for L7
- 90E
- DLW21SZ900HQ2B
- Bypass option for L7
- Stack R247 & R248
  footprints with L7
- EXTERNAL POWER PATH FOR SOURCING, 5V/0.5A
- Note: Refer data sheet USB VBUS Design Guidelines section.
- POWER INDICATION LED: VBUS_TYPEC2
sheet 38
- AUDIO - STEREO LINEOUT - 1
- DAC Supply & Decaps
- CAD Note: Place these decaps near the DVDD supply pin of DAC's
- I2C ADDRESS: 0x50
- CAD Note: Thevnin's termination should
   be placed at the last device
- CAD Note: Place these decaps near the AVDD supply pin of DAC's
- DAC I2C Address Straps
- CAD Note: Thevnin's termination should
   be placed at the last device
- I2C ADDRESS: 0x51
